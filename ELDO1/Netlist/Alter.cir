.alter Class0_Sample20
.include 'Class0/Sample_20'

.alter Class1_Sample20
.include 'Class1/Sample_20'

.alter Class0_Sample21
.include 'Class0/Sample_21'

.alter Class1_Sample21
.include 'Class1/Sample_21'

.alter Class0_Sample22
.include 'Class0/Sample_22'

.alter Class1_Sample22
.include 'Class1/Sample_22'

.alter Class0_Sample23
.include 'Class0/Sample_23'

.alter Class1_Sample23
.include 'Class1/Sample_23'

.alter Class0_Sample24
.include 'Class0/Sample_24'

.alter Class1_Sample24
.include 'Class1/Sample_24'

.alter Class0_Sample25
.include 'Class0/Sample_25'

.alter Class1_Sample25
.include 'Class1/Sample_25'

.alter Class0_Sample26
.include 'Class0/Sample_26'

.alter Class1_Sample26
.include 'Class1/Sample_26'

.alter Class0_Sample27
.include 'Class0/Sample_27'

.alter Class1_Sample27
.include 'Class1/Sample_27'

.alter Class0_Sample28
.include 'Class0/Sample_28'

.alter Class1_Sample28
.include 'Class1/Sample_28'

.alter Class0_Sample29
.include 'Class0/Sample_29'

.alter Class1_Sample29
.include 'Class1/Sample_29'

.alter Class0_Sample30
.include 'Class0/Sample_30'

.alter Class1_Sample30
.include 'Class1/Sample_30'

.alter Class0_Sample31
.include 'Class0/Sample_31'

.alter Class1_Sample31
.include 'Class1/Sample_31'

.alter Class0_Sample32
.include 'Class0/Sample_32'

.alter Class1_Sample32
.include 'Class1/Sample_32'

.alter Class0_Sample33
.include 'Class0/Sample_33'

.alter Class1_Sample33
.include 'Class1/Sample_33'

.alter Class0_Sample34
.include 'Class0/Sample_34'

.alter Class1_Sample34
.include 'Class1/Sample_34'

.alter Class0_Sample35
.include 'Class0/Sample_35'

.alter Class1_Sample35
.include 'Class1/Sample_35'

.alter Class0_Sample36
.include 'Class0/Sample_36'

.alter Class1_Sample36
.include 'Class1/Sample_36'

.alter Class0_Sample37
.include 'Class0/Sample_37'

.alter Class1_Sample37
.include 'Class1/Sample_37'

.alter Class0_Sample38
.include 'Class0/Sample_38'

.alter Class1_Sample38
.include 'Class1/Sample_38'

.alter Class0_Sample39
.include 'Class0/Sample_39'

.alter Class1_Sample39
.include 'Class1/Sample_39'

.alter Class0_Sample40
.include 'Class0/Sample_40'

.alter Class1_Sample40
.include 'Class1/Sample_40'

.alter Class0_Sample41
.include 'Class0/Sample_41'

.alter Class1_Sample41
.include 'Class1/Sample_41'

.alter Class0_Sample42
.include 'Class0/Sample_42'

.alter Class1_Sample42
.include 'Class1/Sample_42'

.alter Class0_Sample43
.include 'Class0/Sample_43'

.alter Class1_Sample43
.include 'Class1/Sample_43'

.alter Class0_Sample44
.include 'Class0/Sample_44'

.alter Class1_Sample44
.include 'Class1/Sample_44'

.alter Class0_Sample45
.include 'Class0/Sample_45'

.alter Class1_Sample45
.include 'Class1/Sample_45'

.alter Class0_Sample46
.include 'Class0/Sample_46'

.alter Class1_Sample46
.include 'Class1/Sample_46'

.alter Class0_Sample47
.include 'Class0/Sample_47'

.alter Class1_Sample47
.include 'Class1/Sample_47'

.alter Class0_Sample48
.include 'Class0/Sample_48'

.alter Class1_Sample48
.include 'Class1/Sample_48'

.alter Class0_Sample49
.include 'Class0/Sample_49'

.alter Class1_Sample49
.include 'Class1/Sample_49'

.alter Class0_Sample50
.include 'Class0/Sample_50'

.alter Class1_Sample50
.include 'Class1/Sample_50'

.alter Class0_Sample51
.include 'Class0/Sample_51'

.alter Class1_Sample51
.include 'Class1/Sample_51'

.alter Class0_Sample52
.include 'Class0/Sample_52'

.alter Class1_Sample52
.include 'Class1/Sample_52'

.alter Class0_Sample53
.include 'Class0/Sample_53'

.alter Class1_Sample53
.include 'Class1/Sample_53'

.alter Class0_Sample54
.include 'Class0/Sample_54'

.alter Class1_Sample54
.include 'Class1/Sample_54'

.alter Class0_Sample55
.include 'Class0/Sample_55'

.alter Class1_Sample55
.include 'Class1/Sample_55'

.alter Class0_Sample56
.include 'Class0/Sample_56'

.alter Class1_Sample56
.include 'Class1/Sample_56'

.alter Class0_Sample57
.include 'Class0/Sample_57'

.alter Class1_Sample57
.include 'Class1/Sample_57'

.alter Class0_Sample58
.include 'Class0/Sample_58'

.alter Class1_Sample58
.include 'Class1/Sample_58'

.alter Class0_Sample59
.include 'Class0/Sample_59'

.alter Class1_Sample59
.include 'Class1/Sample_59'

.alter Class0_Sample60
.include 'Class0/Sample_60'

.alter Class1_Sample60
.include 'Class1/Sample_60'

.alter Class0_Sample61
.include 'Class0/Sample_61'

.alter Class1_Sample61
.include 'Class1/Sample_61'

.alter Class0_Sample62
.include 'Class0/Sample_62'

.alter Class1_Sample62
.include 'Class1/Sample_62'

.alter Class0_Sample63
.include 'Class0/Sample_63'

.alter Class1_Sample63
.include 'Class1/Sample_63'

.alter Class0_Sample64
.include 'Class0/Sample_64'

.alter Class1_Sample64
.include 'Class1/Sample_64'

.alter Class0_Sample65
.include 'Class0/Sample_65'

.alter Class1_Sample65
.include 'Class1/Sample_65'

.alter Class0_Sample66
.include 'Class0/Sample_66'

.alter Class1_Sample66
.include 'Class1/Sample_66'

.alter Class0_Sample67
.include 'Class0/Sample_67'

.alter Class1_Sample67
.include 'Class1/Sample_67'

.alter Class0_Sample68
.include 'Class0/Sample_68'

.alter Class1_Sample68
.include 'Class1/Sample_68'

.alter Class0_Sample69
.include 'Class0/Sample_69'

.alter Class1_Sample69
.include 'Class1/Sample_69'

.alter Class0_Sample70
.include 'Class0/Sample_70'

.alter Class1_Sample70
.include 'Class1/Sample_70'

.alter Class0_Sample71
.include 'Class0/Sample_71'

.alter Class1_Sample71
.include 'Class1/Sample_71'

.alter Class0_Sample72
.include 'Class0/Sample_72'

.alter Class1_Sample72
.include 'Class1/Sample_72'

.alter Class0_Sample73
.include 'Class0/Sample_73'

.alter Class1_Sample73
.include 'Class1/Sample_73'

.alter Class0_Sample74
.include 'Class0/Sample_74'

.alter Class1_Sample74
.include 'Class1/Sample_74'

.alter Class0_Sample75
.include 'Class0/Sample_75'

.alter Class1_Sample75
.include 'Class1/Sample_75'

.alter Class0_Sample76
.include 'Class0/Sample_76'

.alter Class1_Sample76
.include 'Class1/Sample_76'

.alter Class0_Sample77
.include 'Class0/Sample_77'

.alter Class1_Sample77
.include 'Class1/Sample_77'

.alter Class0_Sample78
.include 'Class0/Sample_78'

.alter Class1_Sample78
.include 'Class1/Sample_78'

.alter Class0_Sample79
.include 'Class0/Sample_79'

.alter Class1_Sample79
.include 'Class1/Sample_79'

.alter Class0_Sample80
.include 'Class0/Sample_80'

.alter Class1_Sample80
.include 'Class1/Sample_80'

.alter Class0_Sample81
.include 'Class0/Sample_81'

.alter Class1_Sample81
.include 'Class1/Sample_81'

.alter Class0_Sample82
.include 'Class0/Sample_82'

.alter Class1_Sample82
.include 'Class1/Sample_82'

.alter Class0_Sample83
.include 'Class0/Sample_83'

.alter Class1_Sample83
.include 'Class1/Sample_83'

.alter Class0_Sample84
.include 'Class0/Sample_84'

.alter Class1_Sample84
.include 'Class1/Sample_84'

.alter Class0_Sample85
.include 'Class0/Sample_85'

.alter Class1_Sample85
.include 'Class1/Sample_85'

.alter Class0_Sample86
.include 'Class0/Sample_86'

.alter Class1_Sample86
.include 'Class1/Sample_86'

.alter Class0_Sample87
.include 'Class0/Sample_87'

.alter Class1_Sample87
.include 'Class1/Sample_87'

.alter Class0_Sample88
.include 'Class0/Sample_88'

.alter Class1_Sample88
.include 'Class1/Sample_88'

.alter Class0_Sample89
.include 'Class0/Sample_89'

.alter Class1_Sample89
.include 'Class1/Sample_89'

.alter Class0_Sample90
.include 'Class0/Sample_90'

.alter Class1_Sample90
.include 'Class1/Sample_90'

.alter Class0_Sample91
.include 'Class0/Sample_91'

.alter Class1_Sample91
.include 'Class1/Sample_91'

.alter Class0_Sample92
.include 'Class0/Sample_92'

.alter Class1_Sample92
.include 'Class1/Sample_92'

.alter Class0_Sample93
.include 'Class0/Sample_93'

.alter Class1_Sample93
.include 'Class1/Sample_93'

.alter Class0_Sample94
.include 'Class0/Sample_94'

.alter Class1_Sample94
.include 'Class1/Sample_94'

.alter Class0_Sample95
.include 'Class0/Sample_95'

.alter Class1_Sample95
.include 'Class1/Sample_95'

.alter Class0_Sample96
.include 'Class0/Sample_96'

.alter Class1_Sample96
.include 'Class1/Sample_96'

.alter Class0_Sample97
.include 'Class0/Sample_97'

.alter Class1_Sample97
.include 'Class1/Sample_97'

.alter Class0_Sample98
.include 'Class0/Sample_98'

.alter Class1_Sample98
.include 'Class1/Sample_98'

.alter Class0_Sample99
.include 'Class0/Sample_99'

.alter Class1_Sample99
.include 'Class1/Sample_99'
