.EXTRACT FILE=Power label = pow0 (1.2*integ(I(v0),0N,0.004N)/0.004N)
.EXTRACT FILE=Power label = pow1 (1.2*integ(I(v0),0.004N,0.008N)/0.004N)
.EXTRACT FILE=Power label = pow2 (1.2*integ(I(v0),0.008N,0.012N)/0.004N)
.EXTRACT FILE=Power label = pow3 (1.2*integ(I(v0),0.012N,0.016N)/0.004N)
.EXTRACT FILE=Power label = pow4 (1.2*integ(I(v0),0.016N,0.02N)/0.004N)
.EXTRACT FILE=Power label = pow5 (1.2*integ(I(v0),0.02N,0.024N)/0.004N)
.EXTRACT FILE=Power label = pow6 (1.2*integ(I(v0),0.024N,0.028N)/0.004N)
.EXTRACT FILE=Power label = pow7 (1.2*integ(I(v0),0.028N,0.032N)/0.004N)
.EXTRACT FILE=Power label = pow8 (1.2*integ(I(v0),0.032N,0.036N)/0.004N)
.EXTRACT FILE=Power label = pow9 (1.2*integ(I(v0),0.036N,0.04N)/0.004N)
.EXTRACT FILE=Power label = pow10 (1.2*integ(I(v0),0.04N,0.044N)/0.004N)
.EXTRACT FILE=Power label = pow11 (1.2*integ(I(v0),0.044N,0.048N)/0.004N)
.EXTRACT FILE=Power label = pow12 (1.2*integ(I(v0),0.048N,0.052N)/0.004N)
.EXTRACT FILE=Power label = pow13 (1.2*integ(I(v0),0.052N,0.056N)/0.004N)
.EXTRACT FILE=Power label = pow14 (1.2*integ(I(v0),0.056N,0.06N)/0.004N)
.EXTRACT FILE=Power label = pow15 (1.2*integ(I(v0),0.06N,0.064N)/0.004N)
.EXTRACT FILE=Power label = pow16 (1.2*integ(I(v0),0.064N,0.068N)/0.004N)
.EXTRACT FILE=Power label = pow17 (1.2*integ(I(v0),0.068N,0.072N)/0.004N)
.EXTRACT FILE=Power label = pow18 (1.2*integ(I(v0),0.072N,0.076N)/0.004N)
.EXTRACT FILE=Power label = pow19 (1.2*integ(I(v0),0.076N,0.08N)/0.004N)
.EXTRACT FILE=Power label = pow20 (1.2*integ(I(v0),0.08N,0.084N)/0.004N)
.EXTRACT FILE=Power label = pow21 (1.2*integ(I(v0),0.084N,0.088N)/0.004N)
.EXTRACT FILE=Power label = pow22 (1.2*integ(I(v0),0.088N,0.092N)/0.004N)
.EXTRACT FILE=Power label = pow23 (1.2*integ(I(v0),0.092N,0.096N)/0.004N)
.EXTRACT FILE=Power label = pow24 (1.2*integ(I(v0),0.096N,0.1N)/0.004N)
.EXTRACT FILE=Power label = pow25 (1.2*integ(I(v0),0.1N,0.104N)/0.004N)
.EXTRACT FILE=Power label = pow26 (1.2*integ(I(v0),0.104N,0.108N)/0.004N)
.EXTRACT FILE=Power label = pow27 (1.2*integ(I(v0),0.108N,0.112N)/0.004N)
.EXTRACT FILE=Power label = pow28 (1.2*integ(I(v0),0.112N,0.116N)/0.004N)
.EXTRACT FILE=Power label = pow29 (1.2*integ(I(v0),0.116N,0.12N)/0.004N)
.EXTRACT FILE=Power label = pow30 (1.2*integ(I(v0),0.12N,0.124N)/0.004N)
.EXTRACT FILE=Power label = pow31 (1.2*integ(I(v0),0.124N,0.128N)/0.004N)
.EXTRACT FILE=Power label = pow32 (1.2*integ(I(v0),0.128N,0.132N)/0.004N)
.EXTRACT FILE=Power label = pow33 (1.2*integ(I(v0),0.132N,0.136N)/0.004N)
.EXTRACT FILE=Power label = pow34 (1.2*integ(I(v0),0.136N,0.14N)/0.004N)
.EXTRACT FILE=Power label = pow35 (1.2*integ(I(v0),0.14N,0.144N)/0.004N)
.EXTRACT FILE=Power label = pow36 (1.2*integ(I(v0),0.144N,0.148N)/0.004N)
.EXTRACT FILE=Power label = pow37 (1.2*integ(I(v0),0.148N,0.152N)/0.004N)
.EXTRACT FILE=Power label = pow38 (1.2*integ(I(v0),0.152N,0.156N)/0.004N)
.EXTRACT FILE=Power label = pow39 (1.2*integ(I(v0),0.156N,0.16N)/0.004N)
.EXTRACT FILE=Power label = pow40 (1.2*integ(I(v0),0.16N,0.164N)/0.004N)
.EXTRACT FILE=Power label = pow41 (1.2*integ(I(v0),0.164N,0.168N)/0.004N)
.EXTRACT FILE=Power label = pow42 (1.2*integ(I(v0),0.168N,0.172N)/0.004N)
.EXTRACT FILE=Power label = pow43 (1.2*integ(I(v0),0.172N,0.176N)/0.004N)
.EXTRACT FILE=Power label = pow44 (1.2*integ(I(v0),0.176N,0.18N)/0.004N)
.EXTRACT FILE=Power label = pow45 (1.2*integ(I(v0),0.18N,0.184N)/0.004N)
.EXTRACT FILE=Power label = pow46 (1.2*integ(I(v0),0.184N,0.188N)/0.004N)
.EXTRACT FILE=Power label = pow47 (1.2*integ(I(v0),0.188N,0.192N)/0.004N)
.EXTRACT FILE=Power label = pow48 (1.2*integ(I(v0),0.192N,0.196N)/0.004N)
.EXTRACT FILE=Power label = pow49 (1.2*integ(I(v0),0.196N,0.2N)/0.004N)
.EXTRACT FILE=Power label = pow50 (1.2*integ(I(v0),0.2N,0.204N)/0.004N)
.EXTRACT FILE=Power label = pow51 (1.2*integ(I(v0),0.204N,0.208N)/0.004N)
.EXTRACT FILE=Power label = pow52 (1.2*integ(I(v0),0.208N,0.212N)/0.004N)
.EXTRACT FILE=Power label = pow53 (1.2*integ(I(v0),0.212N,0.216N)/0.004N)
.EXTRACT FILE=Power label = pow54 (1.2*integ(I(v0),0.216N,0.22N)/0.004N)
.EXTRACT FILE=Power label = pow55 (1.2*integ(I(v0),0.22N,0.224N)/0.004N)
.EXTRACT FILE=Power label = pow56 (1.2*integ(I(v0),0.224N,0.228N)/0.004N)
.EXTRACT FILE=Power label = pow57 (1.2*integ(I(v0),0.228N,0.232N)/0.004N)
.EXTRACT FILE=Power label = pow58 (1.2*integ(I(v0),0.232N,0.236N)/0.004N)
.EXTRACT FILE=Power label = pow59 (1.2*integ(I(v0),0.236N,0.24N)/0.004N)
.EXTRACT FILE=Power label = pow60 (1.2*integ(I(v0),0.24N,0.244N)/0.004N)
.EXTRACT FILE=Power label = pow61 (1.2*integ(I(v0),0.244N,0.248N)/0.004N)
.EXTRACT FILE=Power label = pow62 (1.2*integ(I(v0),0.248N,0.252N)/0.004N)
.EXTRACT FILE=Power label = pow63 (1.2*integ(I(v0),0.252N,0.256N)/0.004N)
.EXTRACT FILE=Power label = pow64 (1.2*integ(I(v0),0.256N,0.26N)/0.004N)
.EXTRACT FILE=Power label = pow65 (1.2*integ(I(v0),0.26N,0.264N)/0.004N)
.EXTRACT FILE=Power label = pow66 (1.2*integ(I(v0),0.264N,0.268N)/0.004N)
.EXTRACT FILE=Power label = pow67 (1.2*integ(I(v0),0.268N,0.272N)/0.004N)
.EXTRACT FILE=Power label = pow68 (1.2*integ(I(v0),0.272N,0.276N)/0.004N)
.EXTRACT FILE=Power label = pow69 (1.2*integ(I(v0),0.276N,0.28N)/0.004N)
.EXTRACT FILE=Power label = pow70 (1.2*integ(I(v0),0.28N,0.284N)/0.004N)
.EXTRACT FILE=Power label = pow71 (1.2*integ(I(v0),0.284N,0.288N)/0.004N)
.EXTRACT FILE=Power label = pow72 (1.2*integ(I(v0),0.288N,0.292N)/0.004N)
.EXTRACT FILE=Power label = pow73 (1.2*integ(I(v0),0.292N,0.296N)/0.004N)
.EXTRACT FILE=Power label = pow74 (1.2*integ(I(v0),0.296N,0.3N)/0.004N)
.EXTRACT FILE=Power label = pow75 (1.2*integ(I(v0),0.3N,0.304N)/0.004N)
.EXTRACT FILE=Power label = pow76 (1.2*integ(I(v0),0.304N,0.308N)/0.004N)
.EXTRACT FILE=Power label = pow77 (1.2*integ(I(v0),0.308N,0.312N)/0.004N)
.EXTRACT FILE=Power label = pow78 (1.2*integ(I(v0),0.312N,0.316N)/0.004N)
.EXTRACT FILE=Power label = pow79 (1.2*integ(I(v0),0.316N,0.32N)/0.004N)
.EXTRACT FILE=Power label = pow80 (1.2*integ(I(v0),0.32N,0.324N)/0.004N)
.EXTRACT FILE=Power label = pow81 (1.2*integ(I(v0),0.324N,0.328N)/0.004N)
.EXTRACT FILE=Power label = pow82 (1.2*integ(I(v0),0.328N,0.332N)/0.004N)
.EXTRACT FILE=Power label = pow83 (1.2*integ(I(v0),0.332N,0.336N)/0.004N)
.EXTRACT FILE=Power label = pow84 (1.2*integ(I(v0),0.336N,0.34N)/0.004N)
.EXTRACT FILE=Power label = pow85 (1.2*integ(I(v0),0.34N,0.344N)/0.004N)
.EXTRACT FILE=Power label = pow86 (1.2*integ(I(v0),0.344N,0.348N)/0.004N)
.EXTRACT FILE=Power label = pow87 (1.2*integ(I(v0),0.348N,0.352N)/0.004N)
.EXTRACT FILE=Power label = pow88 (1.2*integ(I(v0),0.352N,0.356N)/0.004N)
.EXTRACT FILE=Power label = pow89 (1.2*integ(I(v0),0.356N,0.36N)/0.004N)
.EXTRACT FILE=Power label = pow90 (1.2*integ(I(v0),0.36N,0.364N)/0.004N)
.EXTRACT FILE=Power label = pow91 (1.2*integ(I(v0),0.364N,0.368N)/0.004N)
.EXTRACT FILE=Power label = pow92 (1.2*integ(I(v0),0.368N,0.372N)/0.004N)
.EXTRACT FILE=Power label = pow93 (1.2*integ(I(v0),0.372N,0.376N)/0.004N)
.EXTRACT FILE=Power label = pow94 (1.2*integ(I(v0),0.376N,0.38N)/0.004N)
.EXTRACT FILE=Power label = pow95 (1.2*integ(I(v0),0.38N,0.384N)/0.004N)
.EXTRACT FILE=Power label = pow96 (1.2*integ(I(v0),0.384N,0.388N)/0.004N)
.EXTRACT FILE=Power label = pow97 (1.2*integ(I(v0),0.388N,0.392N)/0.004N)
.EXTRACT FILE=Power label = pow98 (1.2*integ(I(v0),0.392N,0.396N)/0.004N)
.EXTRACT FILE=Power label = pow99 (1.2*integ(I(v0),0.396N,0.4N)/0.004N)
.EXTRACT FILE=Power label = pow100 (1.2*integ(I(v0),0.4N,0.404N)/0.004N)
.EXTRACT FILE=Power label = pow101 (1.2*integ(I(v0),0.404N,0.408N)/0.004N)
.EXTRACT FILE=Power label = pow102 (1.2*integ(I(v0),0.408N,0.412N)/0.004N)
.EXTRACT FILE=Power label = pow103 (1.2*integ(I(v0),0.412N,0.416N)/0.004N)
.EXTRACT FILE=Power label = pow104 (1.2*integ(I(v0),0.416N,0.42N)/0.004N)
.EXTRACT FILE=Power label = pow105 (1.2*integ(I(v0),0.42N,0.424N)/0.004N)
.EXTRACT FILE=Power label = pow106 (1.2*integ(I(v0),0.424N,0.428N)/0.004N)
.EXTRACT FILE=Power label = pow107 (1.2*integ(I(v0),0.428N,0.432N)/0.004N)
.EXTRACT FILE=Power label = pow108 (1.2*integ(I(v0),0.432N,0.436N)/0.004N)
.EXTRACT FILE=Power label = pow109 (1.2*integ(I(v0),0.436N,0.44N)/0.004N)
.EXTRACT FILE=Power label = pow110 (1.2*integ(I(v0),0.44N,0.444N)/0.004N)
.EXTRACT FILE=Power label = pow111 (1.2*integ(I(v0),0.444N,0.448N)/0.004N)
.EXTRACT FILE=Power label = pow112 (1.2*integ(I(v0),0.448N,0.452N)/0.004N)
.EXTRACT FILE=Power label = pow113 (1.2*integ(I(v0),0.452N,0.456N)/0.004N)
.EXTRACT FILE=Power label = pow114 (1.2*integ(I(v0),0.456N,0.46N)/0.004N)
.EXTRACT FILE=Power label = pow115 (1.2*integ(I(v0),0.46N,0.464N)/0.004N)
.EXTRACT FILE=Power label = pow116 (1.2*integ(I(v0),0.464N,0.468N)/0.004N)
.EXTRACT FILE=Power label = pow117 (1.2*integ(I(v0),0.468N,0.472N)/0.004N)
.EXTRACT FILE=Power label = pow118 (1.2*integ(I(v0),0.472N,0.476N)/0.004N)
.EXTRACT FILE=Power label = pow119 (1.2*integ(I(v0),0.476N,0.48N)/0.004N)
.EXTRACT FILE=Power label = pow120 (1.2*integ(I(v0),0.48N,0.484N)/0.004N)
.EXTRACT FILE=Power label = pow121 (1.2*integ(I(v0),0.484N,0.488N)/0.004N)
.EXTRACT FILE=Power label = pow122 (1.2*integ(I(v0),0.488N,0.492N)/0.004N)
.EXTRACT FILE=Power label = pow123 (1.2*integ(I(v0),0.492N,0.496N)/0.004N)
.EXTRACT FILE=Power label = pow124 (1.2*integ(I(v0),0.496N,0.5N)/0.004N)
.EXTRACT FILE=Power label = pow125 (1.2*integ(I(v0),0.5N,0.504N)/0.004N)
.EXTRACT FILE=Power label = pow126 (1.2*integ(I(v0),0.504N,0.508N)/0.004N)
.EXTRACT FILE=Power label = pow127 (1.2*integ(I(v0),0.508N,0.512N)/0.004N)
.EXTRACT FILE=Power label = pow128 (1.2*integ(I(v0),0.512N,0.516N)/0.004N)
.EXTRACT FILE=Power label = pow129 (1.2*integ(I(v0),0.516N,0.52N)/0.004N)
.EXTRACT FILE=Power label = pow130 (1.2*integ(I(v0),0.52N,0.524N)/0.004N)
.EXTRACT FILE=Power label = pow131 (1.2*integ(I(v0),0.524N,0.528N)/0.004N)
.EXTRACT FILE=Power label = pow132 (1.2*integ(I(v0),0.528N,0.532N)/0.004N)
.EXTRACT FILE=Power label = pow133 (1.2*integ(I(v0),0.532N,0.536N)/0.004N)
.EXTRACT FILE=Power label = pow134 (1.2*integ(I(v0),0.536N,0.54N)/0.004N)
.EXTRACT FILE=Power label = pow135 (1.2*integ(I(v0),0.54N,0.544N)/0.004N)
.EXTRACT FILE=Power label = pow136 (1.2*integ(I(v0),0.544N,0.548N)/0.004N)
.EXTRACT FILE=Power label = pow137 (1.2*integ(I(v0),0.548N,0.552N)/0.004N)
.EXTRACT FILE=Power label = pow138 (1.2*integ(I(v0),0.552N,0.556N)/0.004N)
.EXTRACT FILE=Power label = pow139 (1.2*integ(I(v0),0.556N,0.56N)/0.004N)
.EXTRACT FILE=Power label = pow140 (1.2*integ(I(v0),0.56N,0.564N)/0.004N)
.EXTRACT FILE=Power label = pow141 (1.2*integ(I(v0),0.564N,0.568N)/0.004N)
.EXTRACT FILE=Power label = pow142 (1.2*integ(I(v0),0.568N,0.572N)/0.004N)
.EXTRACT FILE=Power label = pow143 (1.2*integ(I(v0),0.572N,0.576N)/0.004N)
.EXTRACT FILE=Power label = pow144 (1.2*integ(I(v0),0.576N,0.58N)/0.004N)
.EXTRACT FILE=Power label = pow145 (1.2*integ(I(v0),0.58N,0.584N)/0.004N)
.EXTRACT FILE=Power label = pow146 (1.2*integ(I(v0),0.584N,0.588N)/0.004N)
.EXTRACT FILE=Power label = pow147 (1.2*integ(I(v0),0.588N,0.592N)/0.004N)
.EXTRACT FILE=Power label = pow148 (1.2*integ(I(v0),0.592N,0.596N)/0.004N)
.EXTRACT FILE=Power label = pow149 (1.2*integ(I(v0),0.596N,0.6N)/0.004N)
.EXTRACT FILE=Power label = pow150 (1.2*integ(I(v0),0.6N,0.604N)/0.004N)
.EXTRACT FILE=Power label = pow151 (1.2*integ(I(v0),0.604N,0.608N)/0.004N)
.EXTRACT FILE=Power label = pow152 (1.2*integ(I(v0),0.608N,0.612N)/0.004N)
.EXTRACT FILE=Power label = pow153 (1.2*integ(I(v0),0.612N,0.616N)/0.004N)
.EXTRACT FILE=Power label = pow154 (1.2*integ(I(v0),0.616N,0.62N)/0.004N)
.EXTRACT FILE=Power label = pow155 (1.2*integ(I(v0),0.62N,0.624N)/0.004N)
.EXTRACT FILE=Power label = pow156 (1.2*integ(I(v0),0.624N,0.628N)/0.004N)
.EXTRACT FILE=Power label = pow157 (1.2*integ(I(v0),0.628N,0.632N)/0.004N)
.EXTRACT FILE=Power label = pow158 (1.2*integ(I(v0),0.632N,0.636N)/0.004N)
.EXTRACT FILE=Power label = pow159 (1.2*integ(I(v0),0.636N,0.64N)/0.004N)
.EXTRACT FILE=Power label = pow160 (1.2*integ(I(v0),0.64N,0.644N)/0.004N)
.EXTRACT FILE=Power label = pow161 (1.2*integ(I(v0),0.644N,0.648N)/0.004N)
.EXTRACT FILE=Power label = pow162 (1.2*integ(I(v0),0.648N,0.652N)/0.004N)
.EXTRACT FILE=Power label = pow163 (1.2*integ(I(v0),0.652N,0.656N)/0.004N)
.EXTRACT FILE=Power label = pow164 (1.2*integ(I(v0),0.656N,0.66N)/0.004N)
.EXTRACT FILE=Power label = pow165 (1.2*integ(I(v0),0.66N,0.664N)/0.004N)
.EXTRACT FILE=Power label = pow166 (1.2*integ(I(v0),0.664N,0.668N)/0.004N)
.EXTRACT FILE=Power label = pow167 (1.2*integ(I(v0),0.668N,0.672N)/0.004N)
.EXTRACT FILE=Power label = pow168 (1.2*integ(I(v0),0.672N,0.676N)/0.004N)
.EXTRACT FILE=Power label = pow169 (1.2*integ(I(v0),0.676N,0.68N)/0.004N)
.EXTRACT FILE=Power label = pow170 (1.2*integ(I(v0),0.68N,0.684N)/0.004N)
.EXTRACT FILE=Power label = pow171 (1.2*integ(I(v0),0.684N,0.688N)/0.004N)
.EXTRACT FILE=Power label = pow172 (1.2*integ(I(v0),0.688N,0.692N)/0.004N)
.EXTRACT FILE=Power label = pow173 (1.2*integ(I(v0),0.692N,0.696N)/0.004N)
.EXTRACT FILE=Power label = pow174 (1.2*integ(I(v0),0.696N,0.7N)/0.004N)
.EXTRACT FILE=Power label = pow175 (1.2*integ(I(v0),0.7N,0.704N)/0.004N)
.EXTRACT FILE=Power label = pow176 (1.2*integ(I(v0),0.704N,0.708N)/0.004N)
.EXTRACT FILE=Power label = pow177 (1.2*integ(I(v0),0.708N,0.712N)/0.004N)
.EXTRACT FILE=Power label = pow178 (1.2*integ(I(v0),0.712N,0.716N)/0.004N)
.EXTRACT FILE=Power label = pow179 (1.2*integ(I(v0),0.716N,0.72N)/0.004N)
.EXTRACT FILE=Power label = pow180 (1.2*integ(I(v0),0.72N,0.724N)/0.004N)
.EXTRACT FILE=Power label = pow181 (1.2*integ(I(v0),0.724N,0.728N)/0.004N)
.EXTRACT FILE=Power label = pow182 (1.2*integ(I(v0),0.728N,0.732N)/0.004N)
.EXTRACT FILE=Power label = pow183 (1.2*integ(I(v0),0.732N,0.736N)/0.004N)
.EXTRACT FILE=Power label = pow184 (1.2*integ(I(v0),0.736N,0.74N)/0.004N)
.EXTRACT FILE=Power label = pow185 (1.2*integ(I(v0),0.74N,0.744N)/0.004N)
.EXTRACT FILE=Power label = pow186 (1.2*integ(I(v0),0.744N,0.748N)/0.004N)
.EXTRACT FILE=Power label = pow187 (1.2*integ(I(v0),0.748N,0.752N)/0.004N)
.EXTRACT FILE=Power label = pow188 (1.2*integ(I(v0),0.752N,0.756N)/0.004N)
.EXTRACT FILE=Power label = pow189 (1.2*integ(I(v0),0.756N,0.76N)/0.004N)
.EXTRACT FILE=Power label = pow190 (1.2*integ(I(v0),0.76N,0.764N)/0.004N)
.EXTRACT FILE=Power label = pow191 (1.2*integ(I(v0),0.764N,0.768N)/0.004N)
.EXTRACT FILE=Power label = pow192 (1.2*integ(I(v0),0.768N,0.772N)/0.004N)
.EXTRACT FILE=Power label = pow193 (1.2*integ(I(v0),0.772N,0.776N)/0.004N)
.EXTRACT FILE=Power label = pow194 (1.2*integ(I(v0),0.776N,0.78N)/0.004N)
.EXTRACT FILE=Power label = pow195 (1.2*integ(I(v0),0.78N,0.784N)/0.004N)
.EXTRACT FILE=Power label = pow196 (1.2*integ(I(v0),0.784N,0.788N)/0.004N)
.EXTRACT FILE=Power label = pow197 (1.2*integ(I(v0),0.788N,0.792N)/0.004N)
.EXTRACT FILE=Power label = pow198 (1.2*integ(I(v0),0.792N,0.796N)/0.004N)
.EXTRACT FILE=Power label = pow199 (1.2*integ(I(v0),0.796N,0.8N)/0.004N)
.EXTRACT FILE=Power label = pow200 (1.2*integ(I(v0),0.8N,0.804N)/0.004N)
.EXTRACT FILE=Power label = pow201 (1.2*integ(I(v0),0.804N,0.808N)/0.004N)
.EXTRACT FILE=Power label = pow202 (1.2*integ(I(v0),0.808N,0.812N)/0.004N)
.EXTRACT FILE=Power label = pow203 (1.2*integ(I(v0),0.812N,0.816N)/0.004N)
.EXTRACT FILE=Power label = pow204 (1.2*integ(I(v0),0.816N,0.82N)/0.004N)
.EXTRACT FILE=Power label = pow205 (1.2*integ(I(v0),0.82N,0.824N)/0.004N)
.EXTRACT FILE=Power label = pow206 (1.2*integ(I(v0),0.824N,0.828N)/0.004N)
.EXTRACT FILE=Power label = pow207 (1.2*integ(I(v0),0.828N,0.832N)/0.004N)
.EXTRACT FILE=Power label = pow208 (1.2*integ(I(v0),0.832N,0.836N)/0.004N)
.EXTRACT FILE=Power label = pow209 (1.2*integ(I(v0),0.836N,0.84N)/0.004N)
.EXTRACT FILE=Power label = pow210 (1.2*integ(I(v0),0.84N,0.844N)/0.004N)
.EXTRACT FILE=Power label = pow211 (1.2*integ(I(v0),0.844N,0.848N)/0.004N)
.EXTRACT FILE=Power label = pow212 (1.2*integ(I(v0),0.848N,0.852N)/0.004N)
.EXTRACT FILE=Power label = pow213 (1.2*integ(I(v0),0.852N,0.856N)/0.004N)
.EXTRACT FILE=Power label = pow214 (1.2*integ(I(v0),0.856N,0.86N)/0.004N)
.EXTRACT FILE=Power label = pow215 (1.2*integ(I(v0),0.86N,0.864N)/0.004N)
.EXTRACT FILE=Power label = pow216 (1.2*integ(I(v0),0.864N,0.868N)/0.004N)
.EXTRACT FILE=Power label = pow217 (1.2*integ(I(v0),0.868N,0.872N)/0.004N)
.EXTRACT FILE=Power label = pow218 (1.2*integ(I(v0),0.872N,0.876N)/0.004N)
.EXTRACT FILE=Power label = pow219 (1.2*integ(I(v0),0.876N,0.88N)/0.004N)
.EXTRACT FILE=Power label = pow220 (1.2*integ(I(v0),0.88N,0.884N)/0.004N)
.EXTRACT FILE=Power label = pow221 (1.2*integ(I(v0),0.884N,0.888N)/0.004N)
.EXTRACT FILE=Power label = pow222 (1.2*integ(I(v0),0.888N,0.892N)/0.004N)
.EXTRACT FILE=Power label = pow223 (1.2*integ(I(v0),0.892N,0.896N)/0.004N)
.EXTRACT FILE=Power label = pow224 (1.2*integ(I(v0),0.896N,0.9N)/0.004N)
.EXTRACT FILE=Power label = pow225 (1.2*integ(I(v0),0.9N,0.904N)/0.004N)
.EXTRACT FILE=Power label = pow226 (1.2*integ(I(v0),0.904N,0.908N)/0.004N)
.EXTRACT FILE=Power label = pow227 (1.2*integ(I(v0),0.908N,0.912N)/0.004N)
.EXTRACT FILE=Power label = pow228 (1.2*integ(I(v0),0.912N,0.916N)/0.004N)
.EXTRACT FILE=Power label = pow229 (1.2*integ(I(v0),0.916N,0.92N)/0.004N)
.EXTRACT FILE=Power label = pow230 (1.2*integ(I(v0),0.92N,0.924N)/0.004N)
.EXTRACT FILE=Power label = pow231 (1.2*integ(I(v0),0.924N,0.928N)/0.004N)
.EXTRACT FILE=Power label = pow232 (1.2*integ(I(v0),0.928N,0.932N)/0.004N)
.EXTRACT FILE=Power label = pow233 (1.2*integ(I(v0),0.932N,0.936N)/0.004N)
.EXTRACT FILE=Power label = pow234 (1.2*integ(I(v0),0.936N,0.94N)/0.004N)
.EXTRACT FILE=Power label = pow235 (1.2*integ(I(v0),0.94N,0.944N)/0.004N)
.EXTRACT FILE=Power label = pow236 (1.2*integ(I(v0),0.944N,0.948N)/0.004N)
.EXTRACT FILE=Power label = pow237 (1.2*integ(I(v0),0.948N,0.952N)/0.004N)
.EXTRACT FILE=Power label = pow238 (1.2*integ(I(v0),0.952N,0.956N)/0.004N)
.EXTRACT FILE=Power label = pow239 (1.2*integ(I(v0),0.956N,0.96N)/0.004N)
.EXTRACT FILE=Power label = pow240 (1.2*integ(I(v0),0.96N,0.964N)/0.004N)
.EXTRACT FILE=Power label = pow241 (1.2*integ(I(v0),0.964N,0.968N)/0.004N)
.EXTRACT FILE=Power label = pow242 (1.2*integ(I(v0),0.968N,0.972N)/0.004N)
.EXTRACT FILE=Power label = pow243 (1.2*integ(I(v0),0.972N,0.976N)/0.004N)
.EXTRACT FILE=Power label = pow244 (1.2*integ(I(v0),0.976N,0.98N)/0.004N)
.EXTRACT FILE=Power label = pow245 (1.2*integ(I(v0),0.98N,0.984N)/0.004N)
.EXTRACT FILE=Power label = pow246 (1.2*integ(I(v0),0.984N,0.988N)/0.004N)
.EXTRACT FILE=Power label = pow247 (1.2*integ(I(v0),0.988N,0.992N)/0.004N)
.EXTRACT FILE=Power label = pow248 (1.2*integ(I(v0),0.992N,0.996N)/0.004N)
.EXTRACT FILE=Power label = pow249 (1.2*integ(I(v0),0.996N,1.0N)/0.004N)
.EXTRACT FILE=Power label = pow250 (1.2*integ(I(v0),1.0N,1.004N)/0.004N)
.EXTRACT FILE=Power label = pow251 (1.2*integ(I(v0),1.004N,1.008N)/0.004N)
.EXTRACT FILE=Power label = pow252 (1.2*integ(I(v0),1.008N,1.012N)/0.004N)
.EXTRACT FILE=Power label = pow253 (1.2*integ(I(v0),1.012N,1.016N)/0.004N)
.EXTRACT FILE=Power label = pow254 (1.2*integ(I(v0),1.016N,1.02N)/0.004N)
.EXTRACT FILE=Power label = pow255 (1.2*integ(I(v0),1.02N,1.024N)/0.004N)
.EXTRACT FILE=Power label = pow256 (1.2*integ(I(v0),1.024N,1.028N)/0.004N)
.EXTRACT FILE=Power label = pow257 (1.2*integ(I(v0),1.028N,1.032N)/0.004N)
.EXTRACT FILE=Power label = pow258 (1.2*integ(I(v0),1.032N,1.036N)/0.004N)
.EXTRACT FILE=Power label = pow259 (1.2*integ(I(v0),1.036N,1.04N)/0.004N)
.EXTRACT FILE=Power label = pow260 (1.2*integ(I(v0),1.04N,1.044N)/0.004N)
.EXTRACT FILE=Power label = pow261 (1.2*integ(I(v0),1.044N,1.048N)/0.004N)
.EXTRACT FILE=Power label = pow262 (1.2*integ(I(v0),1.048N,1.052N)/0.004N)
.EXTRACT FILE=Power label = pow263 (1.2*integ(I(v0),1.052N,1.056N)/0.004N)
.EXTRACT FILE=Power label = pow264 (1.2*integ(I(v0),1.056N,1.06N)/0.004N)
.EXTRACT FILE=Power label = pow265 (1.2*integ(I(v0),1.06N,1.064N)/0.004N)
.EXTRACT FILE=Power label = pow266 (1.2*integ(I(v0),1.064N,1.068N)/0.004N)
.EXTRACT FILE=Power label = pow267 (1.2*integ(I(v0),1.068N,1.072N)/0.004N)
.EXTRACT FILE=Power label = pow268 (1.2*integ(I(v0),1.072N,1.076N)/0.004N)
.EXTRACT FILE=Power label = pow269 (1.2*integ(I(v0),1.076N,1.08N)/0.004N)
.EXTRACT FILE=Power label = pow270 (1.2*integ(I(v0),1.08N,1.084N)/0.004N)
.EXTRACT FILE=Power label = pow271 (1.2*integ(I(v0),1.084N,1.088N)/0.004N)
.EXTRACT FILE=Power label = pow272 (1.2*integ(I(v0),1.088N,1.092N)/0.004N)
.EXTRACT FILE=Power label = pow273 (1.2*integ(I(v0),1.092N,1.096N)/0.004N)
.EXTRACT FILE=Power label = pow274 (1.2*integ(I(v0),1.096N,1.1N)/0.004N)
.EXTRACT FILE=Power label = pow275 (1.2*integ(I(v0),1.1N,1.104N)/0.004N)
.EXTRACT FILE=Power label = pow276 (1.2*integ(I(v0),1.104N,1.108N)/0.004N)
.EXTRACT FILE=Power label = pow277 (1.2*integ(I(v0),1.108N,1.112N)/0.004N)
.EXTRACT FILE=Power label = pow278 (1.2*integ(I(v0),1.112N,1.116N)/0.004N)
.EXTRACT FILE=Power label = pow279 (1.2*integ(I(v0),1.116N,1.12N)/0.004N)
.EXTRACT FILE=Power label = pow280 (1.2*integ(I(v0),1.12N,1.124N)/0.004N)
.EXTRACT FILE=Power label = pow281 (1.2*integ(I(v0),1.124N,1.128N)/0.004N)
.EXTRACT FILE=Power label = pow282 (1.2*integ(I(v0),1.128N,1.132N)/0.004N)
.EXTRACT FILE=Power label = pow283 (1.2*integ(I(v0),1.132N,1.136N)/0.004N)
.EXTRACT FILE=Power label = pow284 (1.2*integ(I(v0),1.136N,1.14N)/0.004N)
.EXTRACT FILE=Power label = pow285 (1.2*integ(I(v0),1.14N,1.144N)/0.004N)
.EXTRACT FILE=Power label = pow286 (1.2*integ(I(v0),1.144N,1.148N)/0.004N)
.EXTRACT FILE=Power label = pow287 (1.2*integ(I(v0),1.148N,1.152N)/0.004N)
.EXTRACT FILE=Power label = pow288 (1.2*integ(I(v0),1.152N,1.156N)/0.004N)
.EXTRACT FILE=Power label = pow289 (1.2*integ(I(v0),1.156N,1.16N)/0.004N)
.EXTRACT FILE=Power label = pow290 (1.2*integ(I(v0),1.16N,1.164N)/0.004N)
.EXTRACT FILE=Power label = pow291 (1.2*integ(I(v0),1.164N,1.168N)/0.004N)
.EXTRACT FILE=Power label = pow292 (1.2*integ(I(v0),1.168N,1.172N)/0.004N)
.EXTRACT FILE=Power label = pow293 (1.2*integ(I(v0),1.172N,1.176N)/0.004N)
.EXTRACT FILE=Power label = pow294 (1.2*integ(I(v0),1.176N,1.18N)/0.004N)
.EXTRACT FILE=Power label = pow295 (1.2*integ(I(v0),1.18N,1.184N)/0.004N)
.EXTRACT FILE=Power label = pow296 (1.2*integ(I(v0),1.184N,1.188N)/0.004N)
.EXTRACT FILE=Power label = pow297 (1.2*integ(I(v0),1.188N,1.192N)/0.004N)
.EXTRACT FILE=Power label = pow298 (1.2*integ(I(v0),1.192N,1.196N)/0.004N)
.EXTRACT FILE=Power label = pow299 (1.2*integ(I(v0),1.196N,1.2N)/0.004N)
.EXTRACT FILE=Power label = pow300 (1.2*integ(I(v0),1.2N,1.204N)/0.004N)
.EXTRACT FILE=Power label = pow301 (1.2*integ(I(v0),1.204N,1.208N)/0.004N)
.EXTRACT FILE=Power label = pow302 (1.2*integ(I(v0),1.208N,1.212N)/0.004N)
.EXTRACT FILE=Power label = pow303 (1.2*integ(I(v0),1.212N,1.216N)/0.004N)
.EXTRACT FILE=Power label = pow304 (1.2*integ(I(v0),1.216N,1.22N)/0.004N)
.EXTRACT FILE=Power label = pow305 (1.2*integ(I(v0),1.22N,1.224N)/0.004N)
.EXTRACT FILE=Power label = pow306 (1.2*integ(I(v0),1.224N,1.228N)/0.004N)
.EXTRACT FILE=Power label = pow307 (1.2*integ(I(v0),1.228N,1.232N)/0.004N)
.EXTRACT FILE=Power label = pow308 (1.2*integ(I(v0),1.232N,1.236N)/0.004N)
.EXTRACT FILE=Power label = pow309 (1.2*integ(I(v0),1.236N,1.24N)/0.004N)
.EXTRACT FILE=Power label = pow310 (1.2*integ(I(v0),1.24N,1.244N)/0.004N)
.EXTRACT FILE=Power label = pow311 (1.2*integ(I(v0),1.244N,1.248N)/0.004N)
.EXTRACT FILE=Power label = pow312 (1.2*integ(I(v0),1.248N,1.252N)/0.004N)
.EXTRACT FILE=Power label = pow313 (1.2*integ(I(v0),1.252N,1.256N)/0.004N)
.EXTRACT FILE=Power label = pow314 (1.2*integ(I(v0),1.256N,1.26N)/0.004N)
.EXTRACT FILE=Power label = pow315 (1.2*integ(I(v0),1.26N,1.264N)/0.004N)
.EXTRACT FILE=Power label = pow316 (1.2*integ(I(v0),1.264N,1.268N)/0.004N)
.EXTRACT FILE=Power label = pow317 (1.2*integ(I(v0),1.268N,1.272N)/0.004N)
.EXTRACT FILE=Power label = pow318 (1.2*integ(I(v0),1.272N,1.276N)/0.004N)
.EXTRACT FILE=Power label = pow319 (1.2*integ(I(v0),1.276N,1.28N)/0.004N)
.EXTRACT FILE=Power label = pow320 (1.2*integ(I(v0),1.28N,1.284N)/0.004N)
.EXTRACT FILE=Power label = pow321 (1.2*integ(I(v0),1.284N,1.288N)/0.004N)
.EXTRACT FILE=Power label = pow322 (1.2*integ(I(v0),1.288N,1.292N)/0.004N)
.EXTRACT FILE=Power label = pow323 (1.2*integ(I(v0),1.292N,1.296N)/0.004N)
.EXTRACT FILE=Power label = pow324 (1.2*integ(I(v0),1.296N,1.3N)/0.004N)
.EXTRACT FILE=Power label = pow325 (1.2*integ(I(v0),1.3N,1.304N)/0.004N)
.EXTRACT FILE=Power label = pow326 (1.2*integ(I(v0),1.304N,1.308N)/0.004N)
.EXTRACT FILE=Power label = pow327 (1.2*integ(I(v0),1.308N,1.312N)/0.004N)
.EXTRACT FILE=Power label = pow328 (1.2*integ(I(v0),1.312N,1.316N)/0.004N)
.EXTRACT FILE=Power label = pow329 (1.2*integ(I(v0),1.316N,1.32N)/0.004N)
.EXTRACT FILE=Power label = pow330 (1.2*integ(I(v0),1.32N,1.324N)/0.004N)
.EXTRACT FILE=Power label = pow331 (1.2*integ(I(v0),1.324N,1.328N)/0.004N)
.EXTRACT FILE=Power label = pow332 (1.2*integ(I(v0),1.328N,1.332N)/0.004N)
.EXTRACT FILE=Power label = pow333 (1.2*integ(I(v0),1.332N,1.336N)/0.004N)
.EXTRACT FILE=Power label = pow334 (1.2*integ(I(v0),1.336N,1.34N)/0.004N)
.EXTRACT FILE=Power label = pow335 (1.2*integ(I(v0),1.34N,1.344N)/0.004N)
.EXTRACT FILE=Power label = pow336 (1.2*integ(I(v0),1.344N,1.348N)/0.004N)
.EXTRACT FILE=Power label = pow337 (1.2*integ(I(v0),1.348N,1.352N)/0.004N)
.EXTRACT FILE=Power label = pow338 (1.2*integ(I(v0),1.352N,1.356N)/0.004N)
.EXTRACT FILE=Power label = pow339 (1.2*integ(I(v0),1.356N,1.36N)/0.004N)
.EXTRACT FILE=Power label = pow340 (1.2*integ(I(v0),1.36N,1.364N)/0.004N)
.EXTRACT FILE=Power label = pow341 (1.2*integ(I(v0),1.364N,1.368N)/0.004N)
.EXTRACT FILE=Power label = pow342 (1.2*integ(I(v0),1.368N,1.372N)/0.004N)
.EXTRACT FILE=Power label = pow343 (1.2*integ(I(v0),1.372N,1.376N)/0.004N)
.EXTRACT FILE=Power label = pow344 (1.2*integ(I(v0),1.376N,1.38N)/0.004N)
.EXTRACT FILE=Power label = pow345 (1.2*integ(I(v0),1.38N,1.384N)/0.004N)
.EXTRACT FILE=Power label = pow346 (1.2*integ(I(v0),1.384N,1.388N)/0.004N)
.EXTRACT FILE=Power label = pow347 (1.2*integ(I(v0),1.388N,1.392N)/0.004N)
.EXTRACT FILE=Power label = pow348 (1.2*integ(I(v0),1.392N,1.396N)/0.004N)
.EXTRACT FILE=Power label = pow349 (1.2*integ(I(v0),1.396N,1.4N)/0.004N)
.EXTRACT FILE=Power label = pow350 (1.2*integ(I(v0),1.4N,1.404N)/0.004N)
.EXTRACT FILE=Power label = pow351 (1.2*integ(I(v0),1.404N,1.408N)/0.004N)
.EXTRACT FILE=Power label = pow352 (1.2*integ(I(v0),1.408N,1.412N)/0.004N)
.EXTRACT FILE=Power label = pow353 (1.2*integ(I(v0),1.412N,1.416N)/0.004N)
.EXTRACT FILE=Power label = pow354 (1.2*integ(I(v0),1.416N,1.42N)/0.004N)
.EXTRACT FILE=Power label = pow355 (1.2*integ(I(v0),1.42N,1.424N)/0.004N)
.EXTRACT FILE=Power label = pow356 (1.2*integ(I(v0),1.424N,1.428N)/0.004N)
.EXTRACT FILE=Power label = pow357 (1.2*integ(I(v0),1.428N,1.432N)/0.004N)
.EXTRACT FILE=Power label = pow358 (1.2*integ(I(v0),1.432N,1.436N)/0.004N)
.EXTRACT FILE=Power label = pow359 (1.2*integ(I(v0),1.436N,1.44N)/0.004N)
.EXTRACT FILE=Power label = pow360 (1.2*integ(I(v0),1.44N,1.444N)/0.004N)
.EXTRACT FILE=Power label = pow361 (1.2*integ(I(v0),1.444N,1.448N)/0.004N)
.EXTRACT FILE=Power label = pow362 (1.2*integ(I(v0),1.448N,1.452N)/0.004N)
.EXTRACT FILE=Power label = pow363 (1.2*integ(I(v0),1.452N,1.456N)/0.004N)
.EXTRACT FILE=Power label = pow364 (1.2*integ(I(v0),1.456N,1.46N)/0.004N)
.EXTRACT FILE=Power label = pow365 (1.2*integ(I(v0),1.46N,1.464N)/0.004N)
.EXTRACT FILE=Power label = pow366 (1.2*integ(I(v0),1.464N,1.468N)/0.004N)
.EXTRACT FILE=Power label = pow367 (1.2*integ(I(v0),1.468N,1.472N)/0.004N)
.EXTRACT FILE=Power label = pow368 (1.2*integ(I(v0),1.472N,1.476N)/0.004N)
.EXTRACT FILE=Power label = pow369 (1.2*integ(I(v0),1.476N,1.48N)/0.004N)
.EXTRACT FILE=Power label = pow370 (1.2*integ(I(v0),1.48N,1.484N)/0.004N)
.EXTRACT FILE=Power label = pow371 (1.2*integ(I(v0),1.484N,1.488N)/0.004N)
.EXTRACT FILE=Power label = pow372 (1.2*integ(I(v0),1.488N,1.492N)/0.004N)
.EXTRACT FILE=Power label = pow373 (1.2*integ(I(v0),1.492N,1.496N)/0.004N)
.EXTRACT FILE=Power label = pow374 (1.2*integ(I(v0),1.496N,1.5N)/0.004N)
.EXTRACT FILE=Power label = pow375 (1.2*integ(I(v0),1.5N,1.504N)/0.004N)
.EXTRACT FILE=Power label = pow376 (1.2*integ(I(v0),1.504N,1.508N)/0.004N)
.EXTRACT FILE=Power label = pow377 (1.2*integ(I(v0),1.508N,1.512N)/0.004N)
.EXTRACT FILE=Power label = pow378 (1.2*integ(I(v0),1.512N,1.516N)/0.004N)
.EXTRACT FILE=Power label = pow379 (1.2*integ(I(v0),1.516N,1.52N)/0.004N)
.EXTRACT FILE=Power label = pow380 (1.2*integ(I(v0),1.52N,1.524N)/0.004N)
.EXTRACT FILE=Power label = pow381 (1.2*integ(I(v0),1.524N,1.528N)/0.004N)
.EXTRACT FILE=Power label = pow382 (1.2*integ(I(v0),1.528N,1.532N)/0.004N)
.EXTRACT FILE=Power label = pow383 (1.2*integ(I(v0),1.532N,1.536N)/0.004N)
.EXTRACT FILE=Power label = pow384 (1.2*integ(I(v0),1.536N,1.54N)/0.004N)
.EXTRACT FILE=Power label = pow385 (1.2*integ(I(v0),1.54N,1.544N)/0.004N)
.EXTRACT FILE=Power label = pow386 (1.2*integ(I(v0),1.544N,1.548N)/0.004N)
.EXTRACT FILE=Power label = pow387 (1.2*integ(I(v0),1.548N,1.552N)/0.004N)
.EXTRACT FILE=Power label = pow388 (1.2*integ(I(v0),1.552N,1.556N)/0.004N)
.EXTRACT FILE=Power label = pow389 (1.2*integ(I(v0),1.556N,1.56N)/0.004N)
.EXTRACT FILE=Power label = pow390 (1.2*integ(I(v0),1.56N,1.564N)/0.004N)
.EXTRACT FILE=Power label = pow391 (1.2*integ(I(v0),1.564N,1.568N)/0.004N)
.EXTRACT FILE=Power label = pow392 (1.2*integ(I(v0),1.568N,1.572N)/0.004N)
.EXTRACT FILE=Power label = pow393 (1.2*integ(I(v0),1.572N,1.576N)/0.004N)
.EXTRACT FILE=Power label = pow394 (1.2*integ(I(v0),1.576N,1.58N)/0.004N)
.EXTRACT FILE=Power label = pow395 (1.2*integ(I(v0),1.58N,1.584N)/0.004N)
.EXTRACT FILE=Power label = pow396 (1.2*integ(I(v0),1.584N,1.588N)/0.004N)
.EXTRACT FILE=Power label = pow397 (1.2*integ(I(v0),1.588N,1.592N)/0.004N)
.EXTRACT FILE=Power label = pow398 (1.2*integ(I(v0),1.592N,1.596N)/0.004N)
.EXTRACT FILE=Power label = pow399 (1.2*integ(I(v0),1.596N,1.6N)/0.004N)
.EXTRACT FILE=Power label = pow400 (1.2*integ(I(v0),1.6N,1.604N)/0.004N)
.EXTRACT FILE=Power label = pow401 (1.2*integ(I(v0),1.604N,1.608N)/0.004N)
.EXTRACT FILE=Power label = pow402 (1.2*integ(I(v0),1.608N,1.612N)/0.004N)
.EXTRACT FILE=Power label = pow403 (1.2*integ(I(v0),1.612N,1.616N)/0.004N)
.EXTRACT FILE=Power label = pow404 (1.2*integ(I(v0),1.616N,1.62N)/0.004N)
.EXTRACT FILE=Power label = pow405 (1.2*integ(I(v0),1.62N,1.624N)/0.004N)
.EXTRACT FILE=Power label = pow406 (1.2*integ(I(v0),1.624N,1.628N)/0.004N)
.EXTRACT FILE=Power label = pow407 (1.2*integ(I(v0),1.628N,1.632N)/0.004N)
.EXTRACT FILE=Power label = pow408 (1.2*integ(I(v0),1.632N,1.636N)/0.004N)
.EXTRACT FILE=Power label = pow409 (1.2*integ(I(v0),1.636N,1.64N)/0.004N)
.EXTRACT FILE=Power label = pow410 (1.2*integ(I(v0),1.64N,1.644N)/0.004N)
.EXTRACT FILE=Power label = pow411 (1.2*integ(I(v0),1.644N,1.648N)/0.004N)
.EXTRACT FILE=Power label = pow412 (1.2*integ(I(v0),1.648N,1.652N)/0.004N)
.EXTRACT FILE=Power label = pow413 (1.2*integ(I(v0),1.652N,1.656N)/0.004N)
.EXTRACT FILE=Power label = pow414 (1.2*integ(I(v0),1.656N,1.66N)/0.004N)
.EXTRACT FILE=Power label = pow415 (1.2*integ(I(v0),1.66N,1.664N)/0.004N)
.EXTRACT FILE=Power label = pow416 (1.2*integ(I(v0),1.664N,1.668N)/0.004N)
.EXTRACT FILE=Power label = pow417 (1.2*integ(I(v0),1.668N,1.672N)/0.004N)
.EXTRACT FILE=Power label = pow418 (1.2*integ(I(v0),1.672N,1.676N)/0.004N)
.EXTRACT FILE=Power label = pow419 (1.2*integ(I(v0),1.676N,1.68N)/0.004N)
.EXTRACT FILE=Power label = pow420 (1.2*integ(I(v0),1.68N,1.684N)/0.004N)
.EXTRACT FILE=Power label = pow421 (1.2*integ(I(v0),1.684N,1.688N)/0.004N)
.EXTRACT FILE=Power label = pow422 (1.2*integ(I(v0),1.688N,1.692N)/0.004N)
.EXTRACT FILE=Power label = pow423 (1.2*integ(I(v0),1.692N,1.696N)/0.004N)
.EXTRACT FILE=Power label = pow424 (1.2*integ(I(v0),1.696N,1.7N)/0.004N)
.EXTRACT FILE=Power label = pow425 (1.2*integ(I(v0),1.7N,1.704N)/0.004N)
.EXTRACT FILE=Power label = pow426 (1.2*integ(I(v0),1.704N,1.708N)/0.004N)
.EXTRACT FILE=Power label = pow427 (1.2*integ(I(v0),1.708N,1.712N)/0.004N)
.EXTRACT FILE=Power label = pow428 (1.2*integ(I(v0),1.712N,1.716N)/0.004N)
.EXTRACT FILE=Power label = pow429 (1.2*integ(I(v0),1.716N,1.72N)/0.004N)
.EXTRACT FILE=Power label = pow430 (1.2*integ(I(v0),1.72N,1.724N)/0.004N)
.EXTRACT FILE=Power label = pow431 (1.2*integ(I(v0),1.724N,1.728N)/0.004N)
.EXTRACT FILE=Power label = pow432 (1.2*integ(I(v0),1.728N,1.732N)/0.004N)
.EXTRACT FILE=Power label = pow433 (1.2*integ(I(v0),1.732N,1.736N)/0.004N)
.EXTRACT FILE=Power label = pow434 (1.2*integ(I(v0),1.736N,1.74N)/0.004N)
.EXTRACT FILE=Power label = pow435 (1.2*integ(I(v0),1.74N,1.744N)/0.004N)
.EXTRACT FILE=Power label = pow436 (1.2*integ(I(v0),1.744N,1.748N)/0.004N)
.EXTRACT FILE=Power label = pow437 (1.2*integ(I(v0),1.748N,1.752N)/0.004N)
.EXTRACT FILE=Power label = pow438 (1.2*integ(I(v0),1.752N,1.756N)/0.004N)
.EXTRACT FILE=Power label = pow439 (1.2*integ(I(v0),1.756N,1.76N)/0.004N)
.EXTRACT FILE=Power label = pow440 (1.2*integ(I(v0),1.76N,1.764N)/0.004N)
.EXTRACT FILE=Power label = pow441 (1.2*integ(I(v0),1.764N,1.768N)/0.004N)
.EXTRACT FILE=Power label = pow442 (1.2*integ(I(v0),1.768N,1.772N)/0.004N)
.EXTRACT FILE=Power label = pow443 (1.2*integ(I(v0),1.772N,1.776N)/0.004N)
.EXTRACT FILE=Power label = pow444 (1.2*integ(I(v0),1.776N,1.78N)/0.004N)
.EXTRACT FILE=Power label = pow445 (1.2*integ(I(v0),1.78N,1.784N)/0.004N)
.EXTRACT FILE=Power label = pow446 (1.2*integ(I(v0),1.784N,1.788N)/0.004N)
.EXTRACT FILE=Power label = pow447 (1.2*integ(I(v0),1.788N,1.792N)/0.004N)
.EXTRACT FILE=Power label = pow448 (1.2*integ(I(v0),1.792N,1.796N)/0.004N)
.EXTRACT FILE=Power label = pow449 (1.2*integ(I(v0),1.796N,1.8N)/0.004N)
.EXTRACT FILE=Power label = pow450 (1.2*integ(I(v0),1.8N,1.804N)/0.004N)
.EXTRACT FILE=Power label = pow451 (1.2*integ(I(v0),1.804N,1.808N)/0.004N)
.EXTRACT FILE=Power label = pow452 (1.2*integ(I(v0),1.808N,1.812N)/0.004N)
.EXTRACT FILE=Power label = pow453 (1.2*integ(I(v0),1.812N,1.816N)/0.004N)
.EXTRACT FILE=Power label = pow454 (1.2*integ(I(v0),1.816N,1.82N)/0.004N)
.EXTRACT FILE=Power label = pow455 (1.2*integ(I(v0),1.82N,1.824N)/0.004N)
.EXTRACT FILE=Power label = pow456 (1.2*integ(I(v0),1.824N,1.828N)/0.004N)
.EXTRACT FILE=Power label = pow457 (1.2*integ(I(v0),1.828N,1.832N)/0.004N)
.EXTRACT FILE=Power label = pow458 (1.2*integ(I(v0),1.832N,1.836N)/0.004N)
.EXTRACT FILE=Power label = pow459 (1.2*integ(I(v0),1.836N,1.84N)/0.004N)
.EXTRACT FILE=Power label = pow460 (1.2*integ(I(v0),1.84N,1.844N)/0.004N)
.EXTRACT FILE=Power label = pow461 (1.2*integ(I(v0),1.844N,1.848N)/0.004N)
.EXTRACT FILE=Power label = pow462 (1.2*integ(I(v0),1.848N,1.852N)/0.004N)
.EXTRACT FILE=Power label = pow463 (1.2*integ(I(v0),1.852N,1.856N)/0.004N)
.EXTRACT FILE=Power label = pow464 (1.2*integ(I(v0),1.856N,1.86N)/0.004N)
.EXTRACT FILE=Power label = pow465 (1.2*integ(I(v0),1.86N,1.864N)/0.004N)
.EXTRACT FILE=Power label = pow466 (1.2*integ(I(v0),1.864N,1.868N)/0.004N)
.EXTRACT FILE=Power label = pow467 (1.2*integ(I(v0),1.868N,1.872N)/0.004N)
.EXTRACT FILE=Power label = pow468 (1.2*integ(I(v0),1.872N,1.876N)/0.004N)
.EXTRACT FILE=Power label = pow469 (1.2*integ(I(v0),1.876N,1.88N)/0.004N)
.EXTRACT FILE=Power label = pow470 (1.2*integ(I(v0),1.88N,1.884N)/0.004N)
.EXTRACT FILE=Power label = pow471 (1.2*integ(I(v0),1.884N,1.888N)/0.004N)
.EXTRACT FILE=Power label = pow472 (1.2*integ(I(v0),1.888N,1.892N)/0.004N)
.EXTRACT FILE=Power label = pow473 (1.2*integ(I(v0),1.892N,1.896N)/0.004N)
.EXTRACT FILE=Power label = pow474 (1.2*integ(I(v0),1.896N,1.9N)/0.004N)
.EXTRACT FILE=Power label = pow475 (1.2*integ(I(v0),1.9N,1.904N)/0.004N)
.EXTRACT FILE=Power label = pow476 (1.2*integ(I(v0),1.904N,1.908N)/0.004N)
.EXTRACT FILE=Power label = pow477 (1.2*integ(I(v0),1.908N,1.912N)/0.004N)
.EXTRACT FILE=Power label = pow478 (1.2*integ(I(v0),1.912N,1.916N)/0.004N)
.EXTRACT FILE=Power label = pow479 (1.2*integ(I(v0),1.916N,1.92N)/0.004N)
.EXTRACT FILE=Power label = pow480 (1.2*integ(I(v0),1.92N,1.924N)/0.004N)
.EXTRACT FILE=Power label = pow481 (1.2*integ(I(v0),1.924N,1.928N)/0.004N)
.EXTRACT FILE=Power label = pow482 (1.2*integ(I(v0),1.928N,1.932N)/0.004N)
.EXTRACT FILE=Power label = pow483 (1.2*integ(I(v0),1.932N,1.936N)/0.004N)
.EXTRACT FILE=Power label = pow484 (1.2*integ(I(v0),1.936N,1.94N)/0.004N)
.EXTRACT FILE=Power label = pow485 (1.2*integ(I(v0),1.94N,1.944N)/0.004N)
.EXTRACT FILE=Power label = pow486 (1.2*integ(I(v0),1.944N,1.948N)/0.004N)
.EXTRACT FILE=Power label = pow487 (1.2*integ(I(v0),1.948N,1.952N)/0.004N)
.EXTRACT FILE=Power label = pow488 (1.2*integ(I(v0),1.952N,1.956N)/0.004N)
.EXTRACT FILE=Power label = pow489 (1.2*integ(I(v0),1.956N,1.96N)/0.004N)
.EXTRACT FILE=Power label = pow490 (1.2*integ(I(v0),1.96N,1.964N)/0.004N)
.EXTRACT FILE=Power label = pow491 (1.2*integ(I(v0),1.964N,1.968N)/0.004N)
.EXTRACT FILE=Power label = pow492 (1.2*integ(I(v0),1.968N,1.972N)/0.004N)
.EXTRACT FILE=Power label = pow493 (1.2*integ(I(v0),1.972N,1.976N)/0.004N)
.EXTRACT FILE=Power label = pow494 (1.2*integ(I(v0),1.976N,1.98N)/0.004N)
.EXTRACT FILE=Power label = pow495 (1.2*integ(I(v0),1.98N,1.984N)/0.004N)
.EXTRACT FILE=Power label = pow496 (1.2*integ(I(v0),1.984N,1.988N)/0.004N)
.EXTRACT FILE=Power label = pow497 (1.2*integ(I(v0),1.988N,1.992N)/0.004N)
.EXTRACT FILE=Power label = pow498 (1.2*integ(I(v0),1.992N,1.996N)/0.004N)
.EXTRACT FILE=Power label = pow499 (1.2*integ(I(v0),1.996N,2.0N)/0.004N)
.EXTRACT FILE=Power label = pow500 (1.2*integ(I(v0),2.0N,2.004N)/0.004N)
.EXTRACT FILE=Power label = pow501 (1.2*integ(I(v0),2.004N,2.008N)/0.004N)
.EXTRACT FILE=Power label = pow502 (1.2*integ(I(v0),2.008N,2.012N)/0.004N)
.EXTRACT FILE=Power label = pow503 (1.2*integ(I(v0),2.012N,2.016N)/0.004N)
.EXTRACT FILE=Power label = pow504 (1.2*integ(I(v0),2.016N,2.02N)/0.004N)
.EXTRACT FILE=Power label = pow505 (1.2*integ(I(v0),2.02N,2.024N)/0.004N)
.EXTRACT FILE=Power label = pow506 (1.2*integ(I(v0),2.024N,2.028N)/0.004N)
.EXTRACT FILE=Power label = pow507 (1.2*integ(I(v0),2.028N,2.032N)/0.004N)
.EXTRACT FILE=Power label = pow508 (1.2*integ(I(v0),2.032N,2.036N)/0.004N)
.EXTRACT FILE=Power label = pow509 (1.2*integ(I(v0),2.036N,2.04N)/0.004N)
.EXTRACT FILE=Power label = pow510 (1.2*integ(I(v0),2.04N,2.044N)/0.004N)
.EXTRACT FILE=Power label = pow511 (1.2*integ(I(v0),2.044N,2.048N)/0.004N)
.EXTRACT FILE=Power label = pow512 (1.2*integ(I(v0),2.048N,2.052N)/0.004N)
.EXTRACT FILE=Power label = pow513 (1.2*integ(I(v0),2.052N,2.056N)/0.004N)
.EXTRACT FILE=Power label = pow514 (1.2*integ(I(v0),2.056N,2.06N)/0.004N)
.EXTRACT FILE=Power label = pow515 (1.2*integ(I(v0),2.06N,2.064N)/0.004N)
.EXTRACT FILE=Power label = pow516 (1.2*integ(I(v0),2.064N,2.068N)/0.004N)
.EXTRACT FILE=Power label = pow517 (1.2*integ(I(v0),2.068N,2.072N)/0.004N)
.EXTRACT FILE=Power label = pow518 (1.2*integ(I(v0),2.072N,2.076N)/0.004N)
.EXTRACT FILE=Power label = pow519 (1.2*integ(I(v0),2.076N,2.08N)/0.004N)
.EXTRACT FILE=Power label = pow520 (1.2*integ(I(v0),2.08N,2.084N)/0.004N)
.EXTRACT FILE=Power label = pow521 (1.2*integ(I(v0),2.084N,2.088N)/0.004N)
.EXTRACT FILE=Power label = pow522 (1.2*integ(I(v0),2.088N,2.092N)/0.004N)
.EXTRACT FILE=Power label = pow523 (1.2*integ(I(v0),2.092N,2.096N)/0.004N)
.EXTRACT FILE=Power label = pow524 (1.2*integ(I(v0),2.096N,2.1N)/0.004N)
.EXTRACT FILE=Power label = pow525 (1.2*integ(I(v0),2.1N,2.104N)/0.004N)
.EXTRACT FILE=Power label = pow526 (1.2*integ(I(v0),2.104N,2.108N)/0.004N)
.EXTRACT FILE=Power label = pow527 (1.2*integ(I(v0),2.108N,2.112N)/0.004N)
.EXTRACT FILE=Power label = pow528 (1.2*integ(I(v0),2.112N,2.116N)/0.004N)
.EXTRACT FILE=Power label = pow529 (1.2*integ(I(v0),2.116N,2.12N)/0.004N)
.EXTRACT FILE=Power label = pow530 (1.2*integ(I(v0),2.12N,2.124N)/0.004N)
.EXTRACT FILE=Power label = pow531 (1.2*integ(I(v0),2.124N,2.128N)/0.004N)
.EXTRACT FILE=Power label = pow532 (1.2*integ(I(v0),2.128N,2.132N)/0.004N)
.EXTRACT FILE=Power label = pow533 (1.2*integ(I(v0),2.132N,2.136N)/0.004N)
.EXTRACT FILE=Power label = pow534 (1.2*integ(I(v0),2.136N,2.14N)/0.004N)
.EXTRACT FILE=Power label = pow535 (1.2*integ(I(v0),2.14N,2.144N)/0.004N)
.EXTRACT FILE=Power label = pow536 (1.2*integ(I(v0),2.144N,2.148N)/0.004N)
.EXTRACT FILE=Power label = pow537 (1.2*integ(I(v0),2.148N,2.152N)/0.004N)
.EXTRACT FILE=Power label = pow538 (1.2*integ(I(v0),2.152N,2.156N)/0.004N)
.EXTRACT FILE=Power label = pow539 (1.2*integ(I(v0),2.156N,2.16N)/0.004N)
.EXTRACT FILE=Power label = pow540 (1.2*integ(I(v0),2.16N,2.164N)/0.004N)
.EXTRACT FILE=Power label = pow541 (1.2*integ(I(v0),2.164N,2.168N)/0.004N)
.EXTRACT FILE=Power label = pow542 (1.2*integ(I(v0),2.168N,2.172N)/0.004N)
.EXTRACT FILE=Power label = pow543 (1.2*integ(I(v0),2.172N,2.176N)/0.004N)
.EXTRACT FILE=Power label = pow544 (1.2*integ(I(v0),2.176N,2.18N)/0.004N)
.EXTRACT FILE=Power label = pow545 (1.2*integ(I(v0),2.18N,2.184N)/0.004N)
.EXTRACT FILE=Power label = pow546 (1.2*integ(I(v0),2.184N,2.188N)/0.004N)
.EXTRACT FILE=Power label = pow547 (1.2*integ(I(v0),2.188N,2.192N)/0.004N)
.EXTRACT FILE=Power label = pow548 (1.2*integ(I(v0),2.192N,2.196N)/0.004N)
.EXTRACT FILE=Power label = pow549 (1.2*integ(I(v0),2.196N,2.2N)/0.004N)
.EXTRACT FILE=Power label = pow550 (1.2*integ(I(v0),2.2N,2.204N)/0.004N)
.EXTRACT FILE=Power label = pow551 (1.2*integ(I(v0),2.204N,2.208N)/0.004N)
.EXTRACT FILE=Power label = pow552 (1.2*integ(I(v0),2.208N,2.212N)/0.004N)
.EXTRACT FILE=Power label = pow553 (1.2*integ(I(v0),2.212N,2.216N)/0.004N)
.EXTRACT FILE=Power label = pow554 (1.2*integ(I(v0),2.216N,2.22N)/0.004N)
.EXTRACT FILE=Power label = pow555 (1.2*integ(I(v0),2.22N,2.224N)/0.004N)
.EXTRACT FILE=Power label = pow556 (1.2*integ(I(v0),2.224N,2.228N)/0.004N)
.EXTRACT FILE=Power label = pow557 (1.2*integ(I(v0),2.228N,2.232N)/0.004N)
.EXTRACT FILE=Power label = pow558 (1.2*integ(I(v0),2.232N,2.236N)/0.004N)
.EXTRACT FILE=Power label = pow559 (1.2*integ(I(v0),2.236N,2.24N)/0.004N)
.EXTRACT FILE=Power label = pow560 (1.2*integ(I(v0),2.24N,2.244N)/0.004N)
.EXTRACT FILE=Power label = pow561 (1.2*integ(I(v0),2.244N,2.248N)/0.004N)
.EXTRACT FILE=Power label = pow562 (1.2*integ(I(v0),2.248N,2.252N)/0.004N)
.EXTRACT FILE=Power label = pow563 (1.2*integ(I(v0),2.252N,2.256N)/0.004N)
.EXTRACT FILE=Power label = pow564 (1.2*integ(I(v0),2.256N,2.26N)/0.004N)
.EXTRACT FILE=Power label = pow565 (1.2*integ(I(v0),2.26N,2.264N)/0.004N)
.EXTRACT FILE=Power label = pow566 (1.2*integ(I(v0),2.264N,2.268N)/0.004N)
.EXTRACT FILE=Power label = pow567 (1.2*integ(I(v0),2.268N,2.272N)/0.004N)
.EXTRACT FILE=Power label = pow568 (1.2*integ(I(v0),2.272N,2.276N)/0.004N)
.EXTRACT FILE=Power label = pow569 (1.2*integ(I(v0),2.276N,2.28N)/0.004N)
.EXTRACT FILE=Power label = pow570 (1.2*integ(I(v0),2.28N,2.284N)/0.004N)
.EXTRACT FILE=Power label = pow571 (1.2*integ(I(v0),2.284N,2.288N)/0.004N)
.EXTRACT FILE=Power label = pow572 (1.2*integ(I(v0),2.288N,2.292N)/0.004N)
.EXTRACT FILE=Power label = pow573 (1.2*integ(I(v0),2.292N,2.296N)/0.004N)
.EXTRACT FILE=Power label = pow574 (1.2*integ(I(v0),2.296N,2.3N)/0.004N)
.EXTRACT FILE=Power label = pow575 (1.2*integ(I(v0),2.3N,2.304N)/0.004N)
.EXTRACT FILE=Power label = pow576 (1.2*integ(I(v0),2.304N,2.308N)/0.004N)
.EXTRACT FILE=Power label = pow577 (1.2*integ(I(v0),2.308N,2.312N)/0.004N)
.EXTRACT FILE=Power label = pow578 (1.2*integ(I(v0),2.312N,2.316N)/0.004N)
.EXTRACT FILE=Power label = pow579 (1.2*integ(I(v0),2.316N,2.32N)/0.004N)
.EXTRACT FILE=Power label = pow580 (1.2*integ(I(v0),2.32N,2.324N)/0.004N)
.EXTRACT FILE=Power label = pow581 (1.2*integ(I(v0),2.324N,2.328N)/0.004N)
.EXTRACT FILE=Power label = pow582 (1.2*integ(I(v0),2.328N,2.332N)/0.004N)
.EXTRACT FILE=Power label = pow583 (1.2*integ(I(v0),2.332N,2.336N)/0.004N)
.EXTRACT FILE=Power label = pow584 (1.2*integ(I(v0),2.336N,2.34N)/0.004N)
.EXTRACT FILE=Power label = pow585 (1.2*integ(I(v0),2.34N,2.344N)/0.004N)
.EXTRACT FILE=Power label = pow586 (1.2*integ(I(v0),2.344N,2.348N)/0.004N)
.EXTRACT FILE=Power label = pow587 (1.2*integ(I(v0),2.348N,2.352N)/0.004N)
.EXTRACT FILE=Power label = pow588 (1.2*integ(I(v0),2.352N,2.356N)/0.004N)
.EXTRACT FILE=Power label = pow589 (1.2*integ(I(v0),2.356N,2.36N)/0.004N)
.EXTRACT FILE=Power label = pow590 (1.2*integ(I(v0),2.36N,2.364N)/0.004N)
.EXTRACT FILE=Power label = pow591 (1.2*integ(I(v0),2.364N,2.368N)/0.004N)
.EXTRACT FILE=Power label = pow592 (1.2*integ(I(v0),2.368N,2.372N)/0.004N)
.EXTRACT FILE=Power label = pow593 (1.2*integ(I(v0),2.372N,2.376N)/0.004N)
.EXTRACT FILE=Power label = pow594 (1.2*integ(I(v0),2.376N,2.38N)/0.004N)
.EXTRACT FILE=Power label = pow595 (1.2*integ(I(v0),2.38N,2.384N)/0.004N)
.EXTRACT FILE=Power label = pow596 (1.2*integ(I(v0),2.384N,2.388N)/0.004N)
.EXTRACT FILE=Power label = pow597 (1.2*integ(I(v0),2.388N,2.392N)/0.004N)
.EXTRACT FILE=Power label = pow598 (1.2*integ(I(v0),2.392N,2.396N)/0.004N)
.EXTRACT FILE=Power label = pow599 (1.2*integ(I(v0),2.396N,2.4N)/0.004N)
.EXTRACT FILE=Power label = pow600 (1.2*integ(I(v0),2.4N,2.404N)/0.004N)
.EXTRACT FILE=Power label = pow601 (1.2*integ(I(v0),2.404N,2.408N)/0.004N)
.EXTRACT FILE=Power label = pow602 (1.2*integ(I(v0),2.408N,2.412N)/0.004N)
.EXTRACT FILE=Power label = pow603 (1.2*integ(I(v0),2.412N,2.416N)/0.004N)
.EXTRACT FILE=Power label = pow604 (1.2*integ(I(v0),2.416N,2.42N)/0.004N)
.EXTRACT FILE=Power label = pow605 (1.2*integ(I(v0),2.42N,2.424N)/0.004N)
.EXTRACT FILE=Power label = pow606 (1.2*integ(I(v0),2.424N,2.428N)/0.004N)
.EXTRACT FILE=Power label = pow607 (1.2*integ(I(v0),2.428N,2.432N)/0.004N)
.EXTRACT FILE=Power label = pow608 (1.2*integ(I(v0),2.432N,2.436N)/0.004N)
.EXTRACT FILE=Power label = pow609 (1.2*integ(I(v0),2.436N,2.44N)/0.004N)
.EXTRACT FILE=Power label = pow610 (1.2*integ(I(v0),2.44N,2.444N)/0.004N)
.EXTRACT FILE=Power label = pow611 (1.2*integ(I(v0),2.444N,2.448N)/0.004N)
.EXTRACT FILE=Power label = pow612 (1.2*integ(I(v0),2.448N,2.452N)/0.004N)
.EXTRACT FILE=Power label = pow613 (1.2*integ(I(v0),2.452N,2.456N)/0.004N)
.EXTRACT FILE=Power label = pow614 (1.2*integ(I(v0),2.456N,2.46N)/0.004N)
.EXTRACT FILE=Power label = pow615 (1.2*integ(I(v0),2.46N,2.464N)/0.004N)
.EXTRACT FILE=Power label = pow616 (1.2*integ(I(v0),2.464N,2.468N)/0.004N)
.EXTRACT FILE=Power label = pow617 (1.2*integ(I(v0),2.468N,2.472N)/0.004N)
.EXTRACT FILE=Power label = pow618 (1.2*integ(I(v0),2.472N,2.476N)/0.004N)
.EXTRACT FILE=Power label = pow619 (1.2*integ(I(v0),2.476N,2.48N)/0.004N)
.EXTRACT FILE=Power label = pow620 (1.2*integ(I(v0),2.48N,2.484N)/0.004N)
.EXTRACT FILE=Power label = pow621 (1.2*integ(I(v0),2.484N,2.488N)/0.004N)
.EXTRACT FILE=Power label = pow622 (1.2*integ(I(v0),2.488N,2.492N)/0.004N)
.EXTRACT FILE=Power label = pow623 (1.2*integ(I(v0),2.492N,2.496N)/0.004N)
.EXTRACT FILE=Power label = pow624 (1.2*integ(I(v0),2.496N,2.5N)/0.004N)
.EXTRACT FILE=Power label = pow625 (1.2*integ(I(v0),2.5N,2.504N)/0.004N)
.EXTRACT FILE=Power label = pow626 (1.2*integ(I(v0),2.504N,2.508N)/0.004N)
.EXTRACT FILE=Power label = pow627 (1.2*integ(I(v0),2.508N,2.512N)/0.004N)
.EXTRACT FILE=Power label = pow628 (1.2*integ(I(v0),2.512N,2.516N)/0.004N)
.EXTRACT FILE=Power label = pow629 (1.2*integ(I(v0),2.516N,2.52N)/0.004N)
.EXTRACT FILE=Power label = pow630 (1.2*integ(I(v0),2.52N,2.524N)/0.004N)
.EXTRACT FILE=Power label = pow631 (1.2*integ(I(v0),2.524N,2.528N)/0.004N)
.EXTRACT FILE=Power label = pow632 (1.2*integ(I(v0),2.528N,2.532N)/0.004N)
.EXTRACT FILE=Power label = pow633 (1.2*integ(I(v0),2.532N,2.536N)/0.004N)
.EXTRACT FILE=Power label = pow634 (1.2*integ(I(v0),2.536N,2.54N)/0.004N)
.EXTRACT FILE=Power label = pow635 (1.2*integ(I(v0),2.54N,2.544N)/0.004N)
.EXTRACT FILE=Power label = pow636 (1.2*integ(I(v0),2.544N,2.548N)/0.004N)
.EXTRACT FILE=Power label = pow637 (1.2*integ(I(v0),2.548N,2.552N)/0.004N)
.EXTRACT FILE=Power label = pow638 (1.2*integ(I(v0),2.552N,2.556N)/0.004N)
.EXTRACT FILE=Power label = pow639 (1.2*integ(I(v0),2.556N,2.56N)/0.004N)
.EXTRACT FILE=Power label = pow640 (1.2*integ(I(v0),2.56N,2.564N)/0.004N)
.EXTRACT FILE=Power label = pow641 (1.2*integ(I(v0),2.564N,2.568N)/0.004N)
.EXTRACT FILE=Power label = pow642 (1.2*integ(I(v0),2.568N,2.572N)/0.004N)
.EXTRACT FILE=Power label = pow643 (1.2*integ(I(v0),2.572N,2.576N)/0.004N)
.EXTRACT FILE=Power label = pow644 (1.2*integ(I(v0),2.576N,2.58N)/0.004N)
.EXTRACT FILE=Power label = pow645 (1.2*integ(I(v0),2.58N,2.584N)/0.004N)
.EXTRACT FILE=Power label = pow646 (1.2*integ(I(v0),2.584N,2.588N)/0.004N)
.EXTRACT FILE=Power label = pow647 (1.2*integ(I(v0),2.588N,2.592N)/0.004N)
.EXTRACT FILE=Power label = pow648 (1.2*integ(I(v0),2.592N,2.596N)/0.004N)
.EXTRACT FILE=Power label = pow649 (1.2*integ(I(v0),2.596N,2.6N)/0.004N)
.EXTRACT FILE=Power label = pow650 (1.2*integ(I(v0),2.6N,2.604N)/0.004N)
.EXTRACT FILE=Power label = pow651 (1.2*integ(I(v0),2.604N,2.608N)/0.004N)
.EXTRACT FILE=Power label = pow652 (1.2*integ(I(v0),2.608N,2.612N)/0.004N)
.EXTRACT FILE=Power label = pow653 (1.2*integ(I(v0),2.612N,2.616N)/0.004N)
.EXTRACT FILE=Power label = pow654 (1.2*integ(I(v0),2.616N,2.62N)/0.004N)
.EXTRACT FILE=Power label = pow655 (1.2*integ(I(v0),2.62N,2.624N)/0.004N)
.EXTRACT FILE=Power label = pow656 (1.2*integ(I(v0),2.624N,2.628N)/0.004N)
.EXTRACT FILE=Power label = pow657 (1.2*integ(I(v0),2.628N,2.632N)/0.004N)
.EXTRACT FILE=Power label = pow658 (1.2*integ(I(v0),2.632N,2.636N)/0.004N)
.EXTRACT FILE=Power label = pow659 (1.2*integ(I(v0),2.636N,2.64N)/0.004N)
.EXTRACT FILE=Power label = pow660 (1.2*integ(I(v0),2.64N,2.644N)/0.004N)
.EXTRACT FILE=Power label = pow661 (1.2*integ(I(v0),2.644N,2.648N)/0.004N)
.EXTRACT FILE=Power label = pow662 (1.2*integ(I(v0),2.648N,2.652N)/0.004N)
.EXTRACT FILE=Power label = pow663 (1.2*integ(I(v0),2.652N,2.656N)/0.004N)
.EXTRACT FILE=Power label = pow664 (1.2*integ(I(v0),2.656N,2.66N)/0.004N)
.EXTRACT FILE=Power label = pow665 (1.2*integ(I(v0),2.66N,2.664N)/0.004N)
.EXTRACT FILE=Power label = pow666 (1.2*integ(I(v0),2.664N,2.668N)/0.004N)
.EXTRACT FILE=Power label = pow667 (1.2*integ(I(v0),2.668N,2.672N)/0.004N)
.EXTRACT FILE=Power label = pow668 (1.2*integ(I(v0),2.672N,2.676N)/0.004N)
.EXTRACT FILE=Power label = pow669 (1.2*integ(I(v0),2.676N,2.68N)/0.004N)
.EXTRACT FILE=Power label = pow670 (1.2*integ(I(v0),2.68N,2.684N)/0.004N)
.EXTRACT FILE=Power label = pow671 (1.2*integ(I(v0),2.684N,2.688N)/0.004N)
.EXTRACT FILE=Power label = pow672 (1.2*integ(I(v0),2.688N,2.692N)/0.004N)
.EXTRACT FILE=Power label = pow673 (1.2*integ(I(v0),2.692N,2.696N)/0.004N)
.EXTRACT FILE=Power label = pow674 (1.2*integ(I(v0),2.696N,2.7N)/0.004N)
.EXTRACT FILE=Power label = pow675 (1.2*integ(I(v0),2.7N,2.704N)/0.004N)
.EXTRACT FILE=Power label = pow676 (1.2*integ(I(v0),2.704N,2.708N)/0.004N)
.EXTRACT FILE=Power label = pow677 (1.2*integ(I(v0),2.708N,2.712N)/0.004N)
.EXTRACT FILE=Power label = pow678 (1.2*integ(I(v0),2.712N,2.716N)/0.004N)
.EXTRACT FILE=Power label = pow679 (1.2*integ(I(v0),2.716N,2.72N)/0.004N)
.EXTRACT FILE=Power label = pow680 (1.2*integ(I(v0),2.72N,2.724N)/0.004N)
.EXTRACT FILE=Power label = pow681 (1.2*integ(I(v0),2.724N,2.728N)/0.004N)
.EXTRACT FILE=Power label = pow682 (1.2*integ(I(v0),2.728N,2.732N)/0.004N)
.EXTRACT FILE=Power label = pow683 (1.2*integ(I(v0),2.732N,2.736N)/0.004N)
.EXTRACT FILE=Power label = pow684 (1.2*integ(I(v0),2.736N,2.74N)/0.004N)
.EXTRACT FILE=Power label = pow685 (1.2*integ(I(v0),2.74N,2.744N)/0.004N)
.EXTRACT FILE=Power label = pow686 (1.2*integ(I(v0),2.744N,2.748N)/0.004N)
.EXTRACT FILE=Power label = pow687 (1.2*integ(I(v0),2.748N,2.752N)/0.004N)
.EXTRACT FILE=Power label = pow688 (1.2*integ(I(v0),2.752N,2.756N)/0.004N)
.EXTRACT FILE=Power label = pow689 (1.2*integ(I(v0),2.756N,2.76N)/0.004N)
.EXTRACT FILE=Power label = pow690 (1.2*integ(I(v0),2.76N,2.764N)/0.004N)
.EXTRACT FILE=Power label = pow691 (1.2*integ(I(v0),2.764N,2.768N)/0.004N)
.EXTRACT FILE=Power label = pow692 (1.2*integ(I(v0),2.768N,2.772N)/0.004N)
.EXTRACT FILE=Power label = pow693 (1.2*integ(I(v0),2.772N,2.776N)/0.004N)
.EXTRACT FILE=Power label = pow694 (1.2*integ(I(v0),2.776N,2.78N)/0.004N)
.EXTRACT FILE=Power label = pow695 (1.2*integ(I(v0),2.78N,2.784N)/0.004N)
.EXTRACT FILE=Power label = pow696 (1.2*integ(I(v0),2.784N,2.788N)/0.004N)
.EXTRACT FILE=Power label = pow697 (1.2*integ(I(v0),2.788N,2.792N)/0.004N)
.EXTRACT FILE=Power label = pow698 (1.2*integ(I(v0),2.792N,2.796N)/0.004N)
.EXTRACT FILE=Power label = pow699 (1.2*integ(I(v0),2.796N,2.8N)/0.004N)
.EXTRACT FILE=Power label = pow700 (1.2*integ(I(v0),2.8N,2.804N)/0.004N)
.EXTRACT FILE=Power label = pow701 (1.2*integ(I(v0),2.804N,2.808N)/0.004N)
.EXTRACT FILE=Power label = pow702 (1.2*integ(I(v0),2.808N,2.812N)/0.004N)
.EXTRACT FILE=Power label = pow703 (1.2*integ(I(v0),2.812N,2.816N)/0.004N)
.EXTRACT FILE=Power label = pow704 (1.2*integ(I(v0),2.816N,2.82N)/0.004N)
.EXTRACT FILE=Power label = pow705 (1.2*integ(I(v0),2.82N,2.824N)/0.004N)
.EXTRACT FILE=Power label = pow706 (1.2*integ(I(v0),2.824N,2.828N)/0.004N)
.EXTRACT FILE=Power label = pow707 (1.2*integ(I(v0),2.828N,2.832N)/0.004N)
.EXTRACT FILE=Power label = pow708 (1.2*integ(I(v0),2.832N,2.836N)/0.004N)
.EXTRACT FILE=Power label = pow709 (1.2*integ(I(v0),2.836N,2.84N)/0.004N)
.EXTRACT FILE=Power label = pow710 (1.2*integ(I(v0),2.84N,2.844N)/0.004N)
.EXTRACT FILE=Power label = pow711 (1.2*integ(I(v0),2.844N,2.848N)/0.004N)
.EXTRACT FILE=Power label = pow712 (1.2*integ(I(v0),2.848N,2.852N)/0.004N)
.EXTRACT FILE=Power label = pow713 (1.2*integ(I(v0),2.852N,2.856N)/0.004N)
.EXTRACT FILE=Power label = pow714 (1.2*integ(I(v0),2.856N,2.86N)/0.004N)
.EXTRACT FILE=Power label = pow715 (1.2*integ(I(v0),2.86N,2.864N)/0.004N)
.EXTRACT FILE=Power label = pow716 (1.2*integ(I(v0),2.864N,2.868N)/0.004N)
.EXTRACT FILE=Power label = pow717 (1.2*integ(I(v0),2.868N,2.872N)/0.004N)
.EXTRACT FILE=Power label = pow718 (1.2*integ(I(v0),2.872N,2.876N)/0.004N)
.EXTRACT FILE=Power label = pow719 (1.2*integ(I(v0),2.876N,2.88N)/0.004N)
.EXTRACT FILE=Power label = pow720 (1.2*integ(I(v0),2.88N,2.884N)/0.004N)
.EXTRACT FILE=Power label = pow721 (1.2*integ(I(v0),2.884N,2.888N)/0.004N)
.EXTRACT FILE=Power label = pow722 (1.2*integ(I(v0),2.888N,2.892N)/0.004N)
.EXTRACT FILE=Power label = pow723 (1.2*integ(I(v0),2.892N,2.896N)/0.004N)
.EXTRACT FILE=Power label = pow724 (1.2*integ(I(v0),2.896N,2.9N)/0.004N)
.EXTRACT FILE=Power label = pow725 (1.2*integ(I(v0),2.9N,2.904N)/0.004N)
.EXTRACT FILE=Power label = pow726 (1.2*integ(I(v0),2.904N,2.908N)/0.004N)
.EXTRACT FILE=Power label = pow727 (1.2*integ(I(v0),2.908N,2.912N)/0.004N)
.EXTRACT FILE=Power label = pow728 (1.2*integ(I(v0),2.912N,2.916N)/0.004N)
.EXTRACT FILE=Power label = pow729 (1.2*integ(I(v0),2.916N,2.92N)/0.004N)
.EXTRACT FILE=Power label = pow730 (1.2*integ(I(v0),2.92N,2.924N)/0.004N)
.EXTRACT FILE=Power label = pow731 (1.2*integ(I(v0),2.924N,2.928N)/0.004N)
.EXTRACT FILE=Power label = pow732 (1.2*integ(I(v0),2.928N,2.932N)/0.004N)
.EXTRACT FILE=Power label = pow733 (1.2*integ(I(v0),2.932N,2.936N)/0.004N)
.EXTRACT FILE=Power label = pow734 (1.2*integ(I(v0),2.936N,2.94N)/0.004N)
.EXTRACT FILE=Power label = pow735 (1.2*integ(I(v0),2.94N,2.944N)/0.004N)
.EXTRACT FILE=Power label = pow736 (1.2*integ(I(v0),2.944N,2.948N)/0.004N)
.EXTRACT FILE=Power label = pow737 (1.2*integ(I(v0),2.948N,2.952N)/0.004N)
.EXTRACT FILE=Power label = pow738 (1.2*integ(I(v0),2.952N,2.956N)/0.004N)
.EXTRACT FILE=Power label = pow739 (1.2*integ(I(v0),2.956N,2.96N)/0.004N)
.EXTRACT FILE=Power label = pow740 (1.2*integ(I(v0),2.96N,2.964N)/0.004N)
.EXTRACT FILE=Power label = pow741 (1.2*integ(I(v0),2.964N,2.968N)/0.004N)
.EXTRACT FILE=Power label = pow742 (1.2*integ(I(v0),2.968N,2.972N)/0.004N)
.EXTRACT FILE=Power label = pow743 (1.2*integ(I(v0),2.972N,2.976N)/0.004N)
.EXTRACT FILE=Power label = pow744 (1.2*integ(I(v0),2.976N,2.98N)/0.004N)
.EXTRACT FILE=Power label = pow745 (1.2*integ(I(v0),2.98N,2.984N)/0.004N)
.EXTRACT FILE=Power label = pow746 (1.2*integ(I(v0),2.984N,2.988N)/0.004N)
.EXTRACT FILE=Power label = pow747 (1.2*integ(I(v0),2.988N,2.992N)/0.004N)
.EXTRACT FILE=Power label = pow748 (1.2*integ(I(v0),2.992N,2.996N)/0.004N)
.EXTRACT FILE=Power label = pow749 (1.2*integ(I(v0),2.996N,3.0N)/0.004N)
.EXTRACT FILE=Power label = pow750 (1.2*integ(I(v0),3.0N,3.004N)/0.004N)
.EXTRACT FILE=Power label = pow751 (1.2*integ(I(v0),3.004N,3.008N)/0.004N)
.EXTRACT FILE=Power label = pow752 (1.2*integ(I(v0),3.008N,3.012N)/0.004N)
.EXTRACT FILE=Power label = pow753 (1.2*integ(I(v0),3.012N,3.016N)/0.004N)
.EXTRACT FILE=Power label = pow754 (1.2*integ(I(v0),3.016N,3.02N)/0.004N)
.EXTRACT FILE=Power label = pow755 (1.2*integ(I(v0),3.02N,3.024N)/0.004N)
.EXTRACT FILE=Power label = pow756 (1.2*integ(I(v0),3.024N,3.028N)/0.004N)
.EXTRACT FILE=Power label = pow757 (1.2*integ(I(v0),3.028N,3.032N)/0.004N)
.EXTRACT FILE=Power label = pow758 (1.2*integ(I(v0),3.032N,3.036N)/0.004N)
.EXTRACT FILE=Power label = pow759 (1.2*integ(I(v0),3.036N,3.04N)/0.004N)
.EXTRACT FILE=Power label = pow760 (1.2*integ(I(v0),3.04N,3.044N)/0.004N)
.EXTRACT FILE=Power label = pow761 (1.2*integ(I(v0),3.044N,3.048N)/0.004N)
.EXTRACT FILE=Power label = pow762 (1.2*integ(I(v0),3.048N,3.052N)/0.004N)
.EXTRACT FILE=Power label = pow763 (1.2*integ(I(v0),3.052N,3.056N)/0.004N)
.EXTRACT FILE=Power label = pow764 (1.2*integ(I(v0),3.056N,3.06N)/0.004N)
.EXTRACT FILE=Power label = pow765 (1.2*integ(I(v0),3.06N,3.064N)/0.004N)
.EXTRACT FILE=Power label = pow766 (1.2*integ(I(v0),3.064N,3.068N)/0.004N)
.EXTRACT FILE=Power label = pow767 (1.2*integ(I(v0),3.068N,3.072N)/0.004N)
.EXTRACT FILE=Power label = pow768 (1.2*integ(I(v0),3.072N,3.076N)/0.004N)
.EXTRACT FILE=Power label = pow769 (1.2*integ(I(v0),3.076N,3.08N)/0.004N)
.EXTRACT FILE=Power label = pow770 (1.2*integ(I(v0),3.08N,3.084N)/0.004N)
.EXTRACT FILE=Power label = pow771 (1.2*integ(I(v0),3.084N,3.088N)/0.004N)
.EXTRACT FILE=Power label = pow772 (1.2*integ(I(v0),3.088N,3.092N)/0.004N)
.EXTRACT FILE=Power label = pow773 (1.2*integ(I(v0),3.092N,3.096N)/0.004N)
.EXTRACT FILE=Power label = pow774 (1.2*integ(I(v0),3.096N,3.1N)/0.004N)
.EXTRACT FILE=Power label = pow775 (1.2*integ(I(v0),3.1N,3.104N)/0.004N)
.EXTRACT FILE=Power label = pow776 (1.2*integ(I(v0),3.104N,3.108N)/0.004N)
.EXTRACT FILE=Power label = pow777 (1.2*integ(I(v0),3.108N,3.112N)/0.004N)
.EXTRACT FILE=Power label = pow778 (1.2*integ(I(v0),3.112N,3.116N)/0.004N)
.EXTRACT FILE=Power label = pow779 (1.2*integ(I(v0),3.116N,3.12N)/0.004N)
.EXTRACT FILE=Power label = pow780 (1.2*integ(I(v0),3.12N,3.124N)/0.004N)
.EXTRACT FILE=Power label = pow781 (1.2*integ(I(v0),3.124N,3.128N)/0.004N)
.EXTRACT FILE=Power label = pow782 (1.2*integ(I(v0),3.128N,3.132N)/0.004N)
.EXTRACT FILE=Power label = pow783 (1.2*integ(I(v0),3.132N,3.136N)/0.004N)
.EXTRACT FILE=Power label = pow784 (1.2*integ(I(v0),3.136N,3.14N)/0.004N)
.EXTRACT FILE=Power label = pow785 (1.2*integ(I(v0),3.14N,3.144N)/0.004N)
.EXTRACT FILE=Power label = pow786 (1.2*integ(I(v0),3.144N,3.148N)/0.004N)
.EXTRACT FILE=Power label = pow787 (1.2*integ(I(v0),3.148N,3.152N)/0.004N)
.EXTRACT FILE=Power label = pow788 (1.2*integ(I(v0),3.152N,3.156N)/0.004N)
.EXTRACT FILE=Power label = pow789 (1.2*integ(I(v0),3.156N,3.16N)/0.004N)
.EXTRACT FILE=Power label = pow790 (1.2*integ(I(v0),3.16N,3.164N)/0.004N)
.EXTRACT FILE=Power label = pow791 (1.2*integ(I(v0),3.164N,3.168N)/0.004N)
.EXTRACT FILE=Power label = pow792 (1.2*integ(I(v0),3.168N,3.172N)/0.004N)
.EXTRACT FILE=Power label = pow793 (1.2*integ(I(v0),3.172N,3.176N)/0.004N)
.EXTRACT FILE=Power label = pow794 (1.2*integ(I(v0),3.176N,3.18N)/0.004N)
.EXTRACT FILE=Power label = pow795 (1.2*integ(I(v0),3.18N,3.184N)/0.004N)
.EXTRACT FILE=Power label = pow796 (1.2*integ(I(v0),3.184N,3.188N)/0.004N)
.EXTRACT FILE=Power label = pow797 (1.2*integ(I(v0),3.188N,3.192N)/0.004N)
.EXTRACT FILE=Power label = pow798 (1.2*integ(I(v0),3.192N,3.196N)/0.004N)
.EXTRACT FILE=Power label = pow799 (1.2*integ(I(v0),3.196N,3.2N)/0.004N)
.EXTRACT FILE=Power label = pow800 (1.2*integ(I(v0),3.2N,3.204N)/0.004N)
.EXTRACT FILE=Power label = pow801 (1.2*integ(I(v0),3.204N,3.208N)/0.004N)
.EXTRACT FILE=Power label = pow802 (1.2*integ(I(v0),3.208N,3.212N)/0.004N)
.EXTRACT FILE=Power label = pow803 (1.2*integ(I(v0),3.212N,3.216N)/0.004N)
.EXTRACT FILE=Power label = pow804 (1.2*integ(I(v0),3.216N,3.22N)/0.004N)
.EXTRACT FILE=Power label = pow805 (1.2*integ(I(v0),3.22N,3.224N)/0.004N)
.EXTRACT FILE=Power label = pow806 (1.2*integ(I(v0),3.224N,3.228N)/0.004N)
.EXTRACT FILE=Power label = pow807 (1.2*integ(I(v0),3.228N,3.232N)/0.004N)
.EXTRACT FILE=Power label = pow808 (1.2*integ(I(v0),3.232N,3.236N)/0.004N)
.EXTRACT FILE=Power label = pow809 (1.2*integ(I(v0),3.236N,3.24N)/0.004N)
.EXTRACT FILE=Power label = pow810 (1.2*integ(I(v0),3.24N,3.244N)/0.004N)
.EXTRACT FILE=Power label = pow811 (1.2*integ(I(v0),3.244N,3.248N)/0.004N)
.EXTRACT FILE=Power label = pow812 (1.2*integ(I(v0),3.248N,3.252N)/0.004N)
.EXTRACT FILE=Power label = pow813 (1.2*integ(I(v0),3.252N,3.256N)/0.004N)
.EXTRACT FILE=Power label = pow814 (1.2*integ(I(v0),3.256N,3.26N)/0.004N)
.EXTRACT FILE=Power label = pow815 (1.2*integ(I(v0),3.26N,3.264N)/0.004N)
.EXTRACT FILE=Power label = pow816 (1.2*integ(I(v0),3.264N,3.268N)/0.004N)
.EXTRACT FILE=Power label = pow817 (1.2*integ(I(v0),3.268N,3.272N)/0.004N)
.EXTRACT FILE=Power label = pow818 (1.2*integ(I(v0),3.272N,3.276N)/0.004N)
.EXTRACT FILE=Power label = pow819 (1.2*integ(I(v0),3.276N,3.28N)/0.004N)
.EXTRACT FILE=Power label = pow820 (1.2*integ(I(v0),3.28N,3.284N)/0.004N)
.EXTRACT FILE=Power label = pow821 (1.2*integ(I(v0),3.284N,3.288N)/0.004N)
.EXTRACT FILE=Power label = pow822 (1.2*integ(I(v0),3.288N,3.292N)/0.004N)
.EXTRACT FILE=Power label = pow823 (1.2*integ(I(v0),3.292N,3.296N)/0.004N)
.EXTRACT FILE=Power label = pow824 (1.2*integ(I(v0),3.296N,3.3N)/0.004N)
.EXTRACT FILE=Power label = pow825 (1.2*integ(I(v0),3.3N,3.304N)/0.004N)
.EXTRACT FILE=Power label = pow826 (1.2*integ(I(v0),3.304N,3.308N)/0.004N)
.EXTRACT FILE=Power label = pow827 (1.2*integ(I(v0),3.308N,3.312N)/0.004N)
.EXTRACT FILE=Power label = pow828 (1.2*integ(I(v0),3.312N,3.316N)/0.004N)
.EXTRACT FILE=Power label = pow829 (1.2*integ(I(v0),3.316N,3.32N)/0.004N)
.EXTRACT FILE=Power label = pow830 (1.2*integ(I(v0),3.32N,3.324N)/0.004N)
.EXTRACT FILE=Power label = pow831 (1.2*integ(I(v0),3.324N,3.328N)/0.004N)
.EXTRACT FILE=Power label = pow832 (1.2*integ(I(v0),3.328N,3.332N)/0.004N)
.EXTRACT FILE=Power label = pow833 (1.2*integ(I(v0),3.332N,3.336N)/0.004N)
.EXTRACT FILE=Power label = pow834 (1.2*integ(I(v0),3.336N,3.34N)/0.004N)
.EXTRACT FILE=Power label = pow835 (1.2*integ(I(v0),3.34N,3.344N)/0.004N)
.EXTRACT FILE=Power label = pow836 (1.2*integ(I(v0),3.344N,3.348N)/0.004N)
.EXTRACT FILE=Power label = pow837 (1.2*integ(I(v0),3.348N,3.352N)/0.004N)
.EXTRACT FILE=Power label = pow838 (1.2*integ(I(v0),3.352N,3.356N)/0.004N)
.EXTRACT FILE=Power label = pow839 (1.2*integ(I(v0),3.356N,3.36N)/0.004N)
.EXTRACT FILE=Power label = pow840 (1.2*integ(I(v0),3.36N,3.364N)/0.004N)
.EXTRACT FILE=Power label = pow841 (1.2*integ(I(v0),3.364N,3.368N)/0.004N)
.EXTRACT FILE=Power label = pow842 (1.2*integ(I(v0),3.368N,3.372N)/0.004N)
.EXTRACT FILE=Power label = pow843 (1.2*integ(I(v0),3.372N,3.376N)/0.004N)
.EXTRACT FILE=Power label = pow844 (1.2*integ(I(v0),3.376N,3.38N)/0.004N)
.EXTRACT FILE=Power label = pow845 (1.2*integ(I(v0),3.38N,3.384N)/0.004N)
.EXTRACT FILE=Power label = pow846 (1.2*integ(I(v0),3.384N,3.388N)/0.004N)
.EXTRACT FILE=Power label = pow847 (1.2*integ(I(v0),3.388N,3.392N)/0.004N)
.EXTRACT FILE=Power label = pow848 (1.2*integ(I(v0),3.392N,3.396N)/0.004N)
.EXTRACT FILE=Power label = pow849 (1.2*integ(I(v0),3.396N,3.4N)/0.004N)
.EXTRACT FILE=Power label = pow850 (1.2*integ(I(v0),3.4N,3.404N)/0.004N)
.EXTRACT FILE=Power label = pow851 (1.2*integ(I(v0),3.404N,3.408N)/0.004N)
.EXTRACT FILE=Power label = pow852 (1.2*integ(I(v0),3.408N,3.412N)/0.004N)
.EXTRACT FILE=Power label = pow853 (1.2*integ(I(v0),3.412N,3.416N)/0.004N)
.EXTRACT FILE=Power label = pow854 (1.2*integ(I(v0),3.416N,3.42N)/0.004N)
.EXTRACT FILE=Power label = pow855 (1.2*integ(I(v0),3.42N,3.424N)/0.004N)
.EXTRACT FILE=Power label = pow856 (1.2*integ(I(v0),3.424N,3.428N)/0.004N)
.EXTRACT FILE=Power label = pow857 (1.2*integ(I(v0),3.428N,3.432N)/0.004N)
.EXTRACT FILE=Power label = pow858 (1.2*integ(I(v0),3.432N,3.436N)/0.004N)
.EXTRACT FILE=Power label = pow859 (1.2*integ(I(v0),3.436N,3.44N)/0.004N)
.EXTRACT FILE=Power label = pow860 (1.2*integ(I(v0),3.44N,3.444N)/0.004N)
.EXTRACT FILE=Power label = pow861 (1.2*integ(I(v0),3.444N,3.448N)/0.004N)
.EXTRACT FILE=Power label = pow862 (1.2*integ(I(v0),3.448N,3.452N)/0.004N)
.EXTRACT FILE=Power label = pow863 (1.2*integ(I(v0),3.452N,3.456N)/0.004N)
.EXTRACT FILE=Power label = pow864 (1.2*integ(I(v0),3.456N,3.46N)/0.004N)
.EXTRACT FILE=Power label = pow865 (1.2*integ(I(v0),3.46N,3.464N)/0.004N)
.EXTRACT FILE=Power label = pow866 (1.2*integ(I(v0),3.464N,3.468N)/0.004N)
.EXTRACT FILE=Power label = pow867 (1.2*integ(I(v0),3.468N,3.472N)/0.004N)
.EXTRACT FILE=Power label = pow868 (1.2*integ(I(v0),3.472N,3.476N)/0.004N)
.EXTRACT FILE=Power label = pow869 (1.2*integ(I(v0),3.476N,3.48N)/0.004N)
.EXTRACT FILE=Power label = pow870 (1.2*integ(I(v0),3.48N,3.484N)/0.004N)
.EXTRACT FILE=Power label = pow871 (1.2*integ(I(v0),3.484N,3.488N)/0.004N)
.EXTRACT FILE=Power label = pow872 (1.2*integ(I(v0),3.488N,3.492N)/0.004N)
.EXTRACT FILE=Power label = pow873 (1.2*integ(I(v0),3.492N,3.496N)/0.004N)
.EXTRACT FILE=Power label = pow874 (1.2*integ(I(v0),3.496N,3.5N)/0.004N)
.EXTRACT FILE=Power label = pow875 (1.2*integ(I(v0),3.5N,3.504N)/0.004N)
.EXTRACT FILE=Power label = pow876 (1.2*integ(I(v0),3.504N,3.508N)/0.004N)
.EXTRACT FILE=Power label = pow877 (1.2*integ(I(v0),3.508N,3.512N)/0.004N)
.EXTRACT FILE=Power label = pow878 (1.2*integ(I(v0),3.512N,3.516N)/0.004N)
.EXTRACT FILE=Power label = pow879 (1.2*integ(I(v0),3.516N,3.52N)/0.004N)
.EXTRACT FILE=Power label = pow880 (1.2*integ(I(v0),3.52N,3.524N)/0.004N)
.EXTRACT FILE=Power label = pow881 (1.2*integ(I(v0),3.524N,3.528N)/0.004N)
.EXTRACT FILE=Power label = pow882 (1.2*integ(I(v0),3.528N,3.532N)/0.004N)
.EXTRACT FILE=Power label = pow883 (1.2*integ(I(v0),3.532N,3.536N)/0.004N)
.EXTRACT FILE=Power label = pow884 (1.2*integ(I(v0),3.536N,3.54N)/0.004N)
.EXTRACT FILE=Power label = pow885 (1.2*integ(I(v0),3.54N,3.544N)/0.004N)
.EXTRACT FILE=Power label = pow886 (1.2*integ(I(v0),3.544N,3.548N)/0.004N)
.EXTRACT FILE=Power label = pow887 (1.2*integ(I(v0),3.548N,3.552N)/0.004N)
.EXTRACT FILE=Power label = pow888 (1.2*integ(I(v0),3.552N,3.556N)/0.004N)
.EXTRACT FILE=Power label = pow889 (1.2*integ(I(v0),3.556N,3.56N)/0.004N)
.EXTRACT FILE=Power label = pow890 (1.2*integ(I(v0),3.56N,3.564N)/0.004N)
.EXTRACT FILE=Power label = pow891 (1.2*integ(I(v0),3.564N,3.568N)/0.004N)
.EXTRACT FILE=Power label = pow892 (1.2*integ(I(v0),3.568N,3.572N)/0.004N)
.EXTRACT FILE=Power label = pow893 (1.2*integ(I(v0),3.572N,3.576N)/0.004N)
.EXTRACT FILE=Power label = pow894 (1.2*integ(I(v0),3.576N,3.58N)/0.004N)
.EXTRACT FILE=Power label = pow895 (1.2*integ(I(v0),3.58N,3.584N)/0.004N)
.EXTRACT FILE=Power label = pow896 (1.2*integ(I(v0),3.584N,3.588N)/0.004N)
.EXTRACT FILE=Power label = pow897 (1.2*integ(I(v0),3.588N,3.592N)/0.004N)
.EXTRACT FILE=Power label = pow898 (1.2*integ(I(v0),3.592N,3.596N)/0.004N)
.EXTRACT FILE=Power label = pow899 (1.2*integ(I(v0),3.596N,3.6N)/0.004N)
.EXTRACT FILE=Power label = pow900 (1.2*integ(I(v0),3.6N,3.604N)/0.004N)
.EXTRACT FILE=Power label = pow901 (1.2*integ(I(v0),3.604N,3.608N)/0.004N)
.EXTRACT FILE=Power label = pow902 (1.2*integ(I(v0),3.608N,3.612N)/0.004N)
.EXTRACT FILE=Power label = pow903 (1.2*integ(I(v0),3.612N,3.616N)/0.004N)
.EXTRACT FILE=Power label = pow904 (1.2*integ(I(v0),3.616N,3.62N)/0.004N)
.EXTRACT FILE=Power label = pow905 (1.2*integ(I(v0),3.62N,3.624N)/0.004N)
.EXTRACT FILE=Power label = pow906 (1.2*integ(I(v0),3.624N,3.628N)/0.004N)
.EXTRACT FILE=Power label = pow907 (1.2*integ(I(v0),3.628N,3.632N)/0.004N)
.EXTRACT FILE=Power label = pow908 (1.2*integ(I(v0),3.632N,3.636N)/0.004N)
.EXTRACT FILE=Power label = pow909 (1.2*integ(I(v0),3.636N,3.64N)/0.004N)
.EXTRACT FILE=Power label = pow910 (1.2*integ(I(v0),3.64N,3.644N)/0.004N)
.EXTRACT FILE=Power label = pow911 (1.2*integ(I(v0),3.644N,3.648N)/0.004N)
.EXTRACT FILE=Power label = pow912 (1.2*integ(I(v0),3.648N,3.652N)/0.004N)
.EXTRACT FILE=Power label = pow913 (1.2*integ(I(v0),3.652N,3.656N)/0.004N)
.EXTRACT FILE=Power label = pow914 (1.2*integ(I(v0),3.656N,3.66N)/0.004N)
.EXTRACT FILE=Power label = pow915 (1.2*integ(I(v0),3.66N,3.664N)/0.004N)
.EXTRACT FILE=Power label = pow916 (1.2*integ(I(v0),3.664N,3.668N)/0.004N)
.EXTRACT FILE=Power label = pow917 (1.2*integ(I(v0),3.668N,3.672N)/0.004N)
.EXTRACT FILE=Power label = pow918 (1.2*integ(I(v0),3.672N,3.676N)/0.004N)
.EXTRACT FILE=Power label = pow919 (1.2*integ(I(v0),3.676N,3.68N)/0.004N)
.EXTRACT FILE=Power label = pow920 (1.2*integ(I(v0),3.68N,3.684N)/0.004N)
.EXTRACT FILE=Power label = pow921 (1.2*integ(I(v0),3.684N,3.688N)/0.004N)
.EXTRACT FILE=Power label = pow922 (1.2*integ(I(v0),3.688N,3.692N)/0.004N)
.EXTRACT FILE=Power label = pow923 (1.2*integ(I(v0),3.692N,3.696N)/0.004N)
.EXTRACT FILE=Power label = pow924 (1.2*integ(I(v0),3.696N,3.7N)/0.004N)
.EXTRACT FILE=Power label = pow925 (1.2*integ(I(v0),3.7N,3.704N)/0.004N)
.EXTRACT FILE=Power label = pow926 (1.2*integ(I(v0),3.704N,3.708N)/0.004N)
.EXTRACT FILE=Power label = pow927 (1.2*integ(I(v0),3.708N,3.712N)/0.004N)
.EXTRACT FILE=Power label = pow928 (1.2*integ(I(v0),3.712N,3.716N)/0.004N)
.EXTRACT FILE=Power label = pow929 (1.2*integ(I(v0),3.716N,3.72N)/0.004N)
.EXTRACT FILE=Power label = pow930 (1.2*integ(I(v0),3.72N,3.724N)/0.004N)
.EXTRACT FILE=Power label = pow931 (1.2*integ(I(v0),3.724N,3.728N)/0.004N)
.EXTRACT FILE=Power label = pow932 (1.2*integ(I(v0),3.728N,3.732N)/0.004N)
.EXTRACT FILE=Power label = pow933 (1.2*integ(I(v0),3.732N,3.736N)/0.004N)
.EXTRACT FILE=Power label = pow934 (1.2*integ(I(v0),3.736N,3.74N)/0.004N)
.EXTRACT FILE=Power label = pow935 (1.2*integ(I(v0),3.74N,3.744N)/0.004N)
.EXTRACT FILE=Power label = pow936 (1.2*integ(I(v0),3.744N,3.748N)/0.004N)
.EXTRACT FILE=Power label = pow937 (1.2*integ(I(v0),3.748N,3.752N)/0.004N)
.EXTRACT FILE=Power label = pow938 (1.2*integ(I(v0),3.752N,3.756N)/0.004N)
.EXTRACT FILE=Power label = pow939 (1.2*integ(I(v0),3.756N,3.76N)/0.004N)
.EXTRACT FILE=Power label = pow940 (1.2*integ(I(v0),3.76N,3.764N)/0.004N)
.EXTRACT FILE=Power label = pow941 (1.2*integ(I(v0),3.764N,3.768N)/0.004N)
.EXTRACT FILE=Power label = pow942 (1.2*integ(I(v0),3.768N,3.772N)/0.004N)
.EXTRACT FILE=Power label = pow943 (1.2*integ(I(v0),3.772N,3.776N)/0.004N)
.EXTRACT FILE=Power label = pow944 (1.2*integ(I(v0),3.776N,3.78N)/0.004N)
.EXTRACT FILE=Power label = pow945 (1.2*integ(I(v0),3.78N,3.784N)/0.004N)
.EXTRACT FILE=Power label = pow946 (1.2*integ(I(v0),3.784N,3.788N)/0.004N)
.EXTRACT FILE=Power label = pow947 (1.2*integ(I(v0),3.788N,3.792N)/0.004N)
.EXTRACT FILE=Power label = pow948 (1.2*integ(I(v0),3.792N,3.796N)/0.004N)
.EXTRACT FILE=Power label = pow949 (1.2*integ(I(v0),3.796N,3.8N)/0.004N)
.EXTRACT FILE=Power label = pow950 (1.2*integ(I(v0),3.8N,3.804N)/0.004N)
.EXTRACT FILE=Power label = pow951 (1.2*integ(I(v0),3.804N,3.808N)/0.004N)
.EXTRACT FILE=Power label = pow952 (1.2*integ(I(v0),3.808N,3.812N)/0.004N)
.EXTRACT FILE=Power label = pow953 (1.2*integ(I(v0),3.812N,3.816N)/0.004N)
.EXTRACT FILE=Power label = pow954 (1.2*integ(I(v0),3.816N,3.82N)/0.004N)
.EXTRACT FILE=Power label = pow955 (1.2*integ(I(v0),3.82N,3.824N)/0.004N)
.EXTRACT FILE=Power label = pow956 (1.2*integ(I(v0),3.824N,3.828N)/0.004N)
.EXTRACT FILE=Power label = pow957 (1.2*integ(I(v0),3.828N,3.832N)/0.004N)
.EXTRACT FILE=Power label = pow958 (1.2*integ(I(v0),3.832N,3.836N)/0.004N)
.EXTRACT FILE=Power label = pow959 (1.2*integ(I(v0),3.836N,3.84N)/0.004N)
.EXTRACT FILE=Power label = pow960 (1.2*integ(I(v0),3.84N,3.844N)/0.004N)
.EXTRACT FILE=Power label = pow961 (1.2*integ(I(v0),3.844N,3.848N)/0.004N)
.EXTRACT FILE=Power label = pow962 (1.2*integ(I(v0),3.848N,3.852N)/0.004N)
.EXTRACT FILE=Power label = pow963 (1.2*integ(I(v0),3.852N,3.856N)/0.004N)
.EXTRACT FILE=Power label = pow964 (1.2*integ(I(v0),3.856N,3.86N)/0.004N)
.EXTRACT FILE=Power label = pow965 (1.2*integ(I(v0),3.86N,3.864N)/0.004N)
.EXTRACT FILE=Power label = pow966 (1.2*integ(I(v0),3.864N,3.868N)/0.004N)
.EXTRACT FILE=Power label = pow967 (1.2*integ(I(v0),3.868N,3.872N)/0.004N)
.EXTRACT FILE=Power label = pow968 (1.2*integ(I(v0),3.872N,3.876N)/0.004N)
.EXTRACT FILE=Power label = pow969 (1.2*integ(I(v0),3.876N,3.88N)/0.004N)
.EXTRACT FILE=Power label = pow970 (1.2*integ(I(v0),3.88N,3.884N)/0.004N)
.EXTRACT FILE=Power label = pow971 (1.2*integ(I(v0),3.884N,3.888N)/0.004N)
.EXTRACT FILE=Power label = pow972 (1.2*integ(I(v0),3.888N,3.892N)/0.004N)
.EXTRACT FILE=Power label = pow973 (1.2*integ(I(v0),3.892N,3.896N)/0.004N)
.EXTRACT FILE=Power label = pow974 (1.2*integ(I(v0),3.896N,3.9N)/0.004N)
.EXTRACT FILE=Power label = pow975 (1.2*integ(I(v0),3.9N,3.904N)/0.004N)
.EXTRACT FILE=Power label = pow976 (1.2*integ(I(v0),3.904N,3.908N)/0.004N)
.EXTRACT FILE=Power label = pow977 (1.2*integ(I(v0),3.908N,3.912N)/0.004N)
.EXTRACT FILE=Power label = pow978 (1.2*integ(I(v0),3.912N,3.916N)/0.004N)
.EXTRACT FILE=Power label = pow979 (1.2*integ(I(v0),3.916N,3.92N)/0.004N)
.EXTRACT FILE=Power label = pow980 (1.2*integ(I(v0),3.92N,3.924N)/0.004N)
.EXTRACT FILE=Power label = pow981 (1.2*integ(I(v0),3.924N,3.928N)/0.004N)
.EXTRACT FILE=Power label = pow982 (1.2*integ(I(v0),3.928N,3.932N)/0.004N)
.EXTRACT FILE=Power label = pow983 (1.2*integ(I(v0),3.932N,3.936N)/0.004N)
.EXTRACT FILE=Power label = pow984 (1.2*integ(I(v0),3.936N,3.94N)/0.004N)
.EXTRACT FILE=Power label = pow985 (1.2*integ(I(v0),3.94N,3.944N)/0.004N)
.EXTRACT FILE=Power label = pow986 (1.2*integ(I(v0),3.944N,3.948N)/0.004N)
.EXTRACT FILE=Power label = pow987 (1.2*integ(I(v0),3.948N,3.952N)/0.004N)
.EXTRACT FILE=Power label = pow988 (1.2*integ(I(v0),3.952N,3.956N)/0.004N)
.EXTRACT FILE=Power label = pow989 (1.2*integ(I(v0),3.956N,3.96N)/0.004N)
.EXTRACT FILE=Power label = pow990 (1.2*integ(I(v0),3.96N,3.964N)/0.004N)
.EXTRACT FILE=Power label = pow991 (1.2*integ(I(v0),3.964N,3.968N)/0.004N)
.EXTRACT FILE=Power label = pow992 (1.2*integ(I(v0),3.968N,3.972N)/0.004N)
.EXTRACT FILE=Power label = pow993 (1.2*integ(I(v0),3.972N,3.976N)/0.004N)
.EXTRACT FILE=Power label = pow994 (1.2*integ(I(v0),3.976N,3.98N)/0.004N)
.EXTRACT FILE=Power label = pow995 (1.2*integ(I(v0),3.98N,3.984N)/0.004N)
.EXTRACT FILE=Power label = pow996 (1.2*integ(I(v0),3.984N,3.988N)/0.004N)
.EXTRACT FILE=Power label = pow997 (1.2*integ(I(v0),3.988N,3.992N)/0.004N)
.EXTRACT FILE=Power label = pow998 (1.2*integ(I(v0),3.992N,3.996N)/0.004N)
.EXTRACT FILE=Power label = pow999 (1.2*integ(I(v0),3.996N,4.0N)/0.004N)
