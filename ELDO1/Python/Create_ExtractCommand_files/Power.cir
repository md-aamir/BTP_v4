.EXTRACT FILE=Power label = pow0 (1.2*integ(I(v0),0N,0.1N)/0.01N)
.EXTRACT FILE=Power label = pow1 (1.2*integ(I(v0),0.1N,0.11N)/0.01N)
.EXTRACT FILE=Power label = pow2 (1.2*integ(I(v0),0.11N,0.12N)/0.01N)
.EXTRACT FILE=Power label = pow3 (1.2*integ(I(v0),0.12N,0.13N)/0.01N)
.EXTRACT FILE=Power label = pow4 (1.2*integ(I(v0),0.13N,0.14N)/0.01N)
.EXTRACT FILE=Power label = pow5 (1.2*integ(I(v0),0.14N,0.15N)/0.01N)
.EXTRACT FILE=Power label = pow6 (1.2*integ(I(v0),0.15N,0.16N)/0.01N)
.EXTRACT FILE=Power label = pow7 (1.2*integ(I(v0),0.16N,0.17N)/0.01N)
.EXTRACT FILE=Power label = pow8 (1.2*integ(I(v0),0.17N,0.18N)/0.01N)
.EXTRACT FILE=Power label = pow9 (1.2*integ(I(v0),0.18N,0.19N)/0.01N)
.EXTRACT FILE=Power label = pow10 (1.2*integ(I(v0),0.19N,0.2N)/0.01N)
.EXTRACT FILE=Power label = pow11 (1.2*integ(I(v0),0.2N,0.21N)/0.01N)
.EXTRACT FILE=Power label = pow12 (1.2*integ(I(v0),0.21N,0.22N)/0.01N)
.EXTRACT FILE=Power label = pow13 (1.2*integ(I(v0),0.22N,0.23N)/0.01N)
.EXTRACT FILE=Power label = pow14 (1.2*integ(I(v0),0.23N,0.24N)/0.01N)
.EXTRACT FILE=Power label = pow15 (1.2*integ(I(v0),0.24N,0.25N)/0.01N)
.EXTRACT FILE=Power label = pow16 (1.2*integ(I(v0),0.25N,0.26N)/0.01N)
.EXTRACT FILE=Power label = pow17 (1.2*integ(I(v0),0.26N,0.27N)/0.01N)
.EXTRACT FILE=Power label = pow18 (1.2*integ(I(v0),0.27N,0.28N)/0.01N)
.EXTRACT FILE=Power label = pow19 (1.2*integ(I(v0),0.28N,0.29N)/0.01N)
.EXTRACT FILE=Power label = pow20 (1.2*integ(I(v0),0.29N,0.3N)/0.01N)
.EXTRACT FILE=Power label = pow21 (1.2*integ(I(v0),0.3N,0.31N)/0.01N)
.EXTRACT FILE=Power label = pow22 (1.2*integ(I(v0),0.31N,0.32N)/0.01N)
.EXTRACT FILE=Power label = pow23 (1.2*integ(I(v0),0.32N,0.33N)/0.01N)
.EXTRACT FILE=Power label = pow24 (1.2*integ(I(v0),0.33N,0.34N)/0.01N)
.EXTRACT FILE=Power label = pow25 (1.2*integ(I(v0),0.34N,0.35N)/0.01N)
.EXTRACT FILE=Power label = pow26 (1.2*integ(I(v0),0.35N,0.36N)/0.01N)
.EXTRACT FILE=Power label = pow27 (1.2*integ(I(v0),0.36N,0.37N)/0.01N)
.EXTRACT FILE=Power label = pow28 (1.2*integ(I(v0),0.37N,0.38N)/0.01N)
.EXTRACT FILE=Power label = pow29 (1.2*integ(I(v0),0.38N,0.39N)/0.01N)
.EXTRACT FILE=Power label = pow30 (1.2*integ(I(v0),0.39N,0.4N)/0.01N)
.EXTRACT FILE=Power label = pow31 (1.2*integ(I(v0),0.4N,0.41N)/0.01N)
.EXTRACT FILE=Power label = pow32 (1.2*integ(I(v0),0.41N,0.42N)/0.01N)
.EXTRACT FILE=Power label = pow33 (1.2*integ(I(v0),0.42N,0.43N)/0.01N)
.EXTRACT FILE=Power label = pow34 (1.2*integ(I(v0),0.43N,0.44N)/0.01N)
.EXTRACT FILE=Power label = pow35 (1.2*integ(I(v0),0.44N,0.45N)/0.01N)
.EXTRACT FILE=Power label = pow36 (1.2*integ(I(v0),0.45N,0.46N)/0.01N)
.EXTRACT FILE=Power label = pow37 (1.2*integ(I(v0),0.46N,0.47N)/0.01N)
.EXTRACT FILE=Power label = pow38 (1.2*integ(I(v0),0.47N,0.48N)/0.01N)
.EXTRACT FILE=Power label = pow39 (1.2*integ(I(v0),0.48N,0.49N)/0.01N)
.EXTRACT FILE=Power label = pow40 (1.2*integ(I(v0),0.49N,0.5N)/0.01N)
.EXTRACT FILE=Power label = pow41 (1.2*integ(I(v0),0.5N,0.51N)/0.01N)
.EXTRACT FILE=Power label = pow42 (1.2*integ(I(v0),0.51N,0.52N)/0.01N)
.EXTRACT FILE=Power label = pow43 (1.2*integ(I(v0),0.52N,0.53N)/0.01N)
.EXTRACT FILE=Power label = pow44 (1.2*integ(I(v0),0.53N,0.54N)/0.01N)
.EXTRACT FILE=Power label = pow45 (1.2*integ(I(v0),0.54N,0.55N)/0.01N)
.EXTRACT FILE=Power label = pow46 (1.2*integ(I(v0),0.55N,0.56N)/0.01N)
.EXTRACT FILE=Power label = pow47 (1.2*integ(I(v0),0.56N,0.57N)/0.01N)
.EXTRACT FILE=Power label = pow48 (1.2*integ(I(v0),0.57N,0.58N)/0.01N)
.EXTRACT FILE=Power label = pow49 (1.2*integ(I(v0),0.58N,0.59N)/0.01N)
.EXTRACT FILE=Power label = pow50 (1.2*integ(I(v0),0.59N,0.6N)/0.01N)
.EXTRACT FILE=Power label = pow51 (1.2*integ(I(v0),0.6N,0.61N)/0.01N)
.EXTRACT FILE=Power label = pow52 (1.2*integ(I(v0),0.61N,0.62N)/0.01N)
.EXTRACT FILE=Power label = pow53 (1.2*integ(I(v0),0.62N,0.63N)/0.01N)
.EXTRACT FILE=Power label = pow54 (1.2*integ(I(v0),0.63N,0.64N)/0.01N)
.EXTRACT FILE=Power label = pow55 (1.2*integ(I(v0),0.64N,0.65N)/0.01N)
.EXTRACT FILE=Power label = pow56 (1.2*integ(I(v0),0.65N,0.66N)/0.01N)
.EXTRACT FILE=Power label = pow57 (1.2*integ(I(v0),0.66N,0.67N)/0.01N)
.EXTRACT FILE=Power label = pow58 (1.2*integ(I(v0),0.67N,0.68N)/0.01N)
.EXTRACT FILE=Power label = pow59 (1.2*integ(I(v0),0.68N,0.69N)/0.01N)
.EXTRACT FILE=Power label = pow60 (1.2*integ(I(v0),0.69N,0.7N)/0.01N)
.EXTRACT FILE=Power label = pow61 (1.2*integ(I(v0),0.7N,0.71N)/0.01N)
.EXTRACT FILE=Power label = pow62 (1.2*integ(I(v0),0.71N,0.72N)/0.01N)
.EXTRACT FILE=Power label = pow63 (1.2*integ(I(v0),0.72N,0.73N)/0.01N)
.EXTRACT FILE=Power label = pow64 (1.2*integ(I(v0),0.73N,0.74N)/0.01N)
.EXTRACT FILE=Power label = pow65 (1.2*integ(I(v0),0.74N,0.75N)/0.01N)
.EXTRACT FILE=Power label = pow66 (1.2*integ(I(v0),0.75N,0.76N)/0.01N)
.EXTRACT FILE=Power label = pow67 (1.2*integ(I(v0),0.76N,0.77N)/0.01N)
.EXTRACT FILE=Power label = pow68 (1.2*integ(I(v0),0.77N,0.78N)/0.01N)
.EXTRACT FILE=Power label = pow69 (1.2*integ(I(v0),0.78N,0.79N)/0.01N)
.EXTRACT FILE=Power label = pow70 (1.2*integ(I(v0),0.79N,0.8N)/0.01N)
.EXTRACT FILE=Power label = pow71 (1.2*integ(I(v0),0.8N,0.81N)/0.01N)
.EXTRACT FILE=Power label = pow72 (1.2*integ(I(v0),0.81N,0.82N)/0.01N)
.EXTRACT FILE=Power label = pow73 (1.2*integ(I(v0),0.82N,0.83N)/0.01N)
.EXTRACT FILE=Power label = pow74 (1.2*integ(I(v0),0.83N,0.84N)/0.01N)
.EXTRACT FILE=Power label = pow75 (1.2*integ(I(v0),0.84N,0.85N)/0.01N)
.EXTRACT FILE=Power label = pow76 (1.2*integ(I(v0),0.85N,0.86N)/0.01N)
.EXTRACT FILE=Power label = pow77 (1.2*integ(I(v0),0.86N,0.87N)/0.01N)
.EXTRACT FILE=Power label = pow78 (1.2*integ(I(v0),0.87N,0.88N)/0.01N)
.EXTRACT FILE=Power label = pow79 (1.2*integ(I(v0),0.88N,0.89N)/0.01N)
.EXTRACT FILE=Power label = pow80 (1.2*integ(I(v0),0.89N,0.9N)/0.01N)
.EXTRACT FILE=Power label = pow81 (1.2*integ(I(v0),0.9N,0.91N)/0.01N)
.EXTRACT FILE=Power label = pow82 (1.2*integ(I(v0),0.91N,0.92N)/0.01N)
.EXTRACT FILE=Power label = pow83 (1.2*integ(I(v0),0.92N,0.93N)/0.01N)
.EXTRACT FILE=Power label = pow84 (1.2*integ(I(v0),0.93N,0.94N)/0.01N)
.EXTRACT FILE=Power label = pow85 (1.2*integ(I(v0),0.94N,0.95N)/0.01N)
.EXTRACT FILE=Power label = pow86 (1.2*integ(I(v0),0.95N,0.96N)/0.01N)
.EXTRACT FILE=Power label = pow87 (1.2*integ(I(v0),0.96N,0.97N)/0.01N)
.EXTRACT FILE=Power label = pow88 (1.2*integ(I(v0),0.97N,0.98N)/0.01N)
.EXTRACT FILE=Power label = pow89 (1.2*integ(I(v0),0.98N,0.99N)/0.01N)
.EXTRACT FILE=Power label = pow90 (1.2*integ(I(v0),0.99N,1.0N)/0.01N)
.EXTRACT FILE=Power label = pow91 (1.2*integ(I(v0),1.0N,1.01N)/0.01N)
.EXTRACT FILE=Power label = pow92 (1.2*integ(I(v0),1.01N,1.02N)/0.01N)
.EXTRACT FILE=Power label = pow93 (1.2*integ(I(v0),1.02N,1.03N)/0.01N)
.EXTRACT FILE=Power label = pow94 (1.2*integ(I(v0),1.03N,1.04N)/0.01N)
.EXTRACT FILE=Power label = pow95 (1.2*integ(I(v0),1.04N,1.05N)/0.01N)
.EXTRACT FILE=Power label = pow96 (1.2*integ(I(v0),1.05N,1.06N)/0.01N)
.EXTRACT FILE=Power label = pow97 (1.2*integ(I(v0),1.06N,1.07N)/0.01N)
.EXTRACT FILE=Power label = pow98 (1.2*integ(I(v0),1.07N,1.08N)/0.01N)
.EXTRACT FILE=Power label = pow99 (1.2*integ(I(v0),1.08N,1.09N)/0.01N)
.EXTRACT FILE=Power label = pow100 (1.2*integ(I(v0),1.09N,1.1N)/0.01N)
.EXTRACT FILE=Power label = pow101 (1.2*integ(I(v0),1.1N,1.11N)/0.01N)
.EXTRACT FILE=Power label = pow102 (1.2*integ(I(v0),1.11N,1.12N)/0.01N)
.EXTRACT FILE=Power label = pow103 (1.2*integ(I(v0),1.12N,1.13N)/0.01N)
.EXTRACT FILE=Power label = pow104 (1.2*integ(I(v0),1.13N,1.14N)/0.01N)
.EXTRACT FILE=Power label = pow105 (1.2*integ(I(v0),1.14N,1.15N)/0.01N)
.EXTRACT FILE=Power label = pow106 (1.2*integ(I(v0),1.15N,1.16N)/0.01N)
.EXTRACT FILE=Power label = pow107 (1.2*integ(I(v0),1.16N,1.17N)/0.01N)
.EXTRACT FILE=Power label = pow108 (1.2*integ(I(v0),1.17N,1.18N)/0.01N)
.EXTRACT FILE=Power label = pow109 (1.2*integ(I(v0),1.18N,1.19N)/0.01N)
.EXTRACT FILE=Power label = pow110 (1.2*integ(I(v0),1.19N,1.2N)/0.01N)
.EXTRACT FILE=Power label = pow111 (1.2*integ(I(v0),1.2N,1.21N)/0.01N)
.EXTRACT FILE=Power label = pow112 (1.2*integ(I(v0),1.21N,1.22N)/0.01N)
.EXTRACT FILE=Power label = pow113 (1.2*integ(I(v0),1.22N,1.23N)/0.01N)
.EXTRACT FILE=Power label = pow114 (1.2*integ(I(v0),1.23N,1.24N)/0.01N)
.EXTRACT FILE=Power label = pow115 (1.2*integ(I(v0),1.24N,1.25N)/0.01N)
.EXTRACT FILE=Power label = pow116 (1.2*integ(I(v0),1.25N,1.26N)/0.01N)
.EXTRACT FILE=Power label = pow117 (1.2*integ(I(v0),1.26N,1.27N)/0.01N)
.EXTRACT FILE=Power label = pow118 (1.2*integ(I(v0),1.27N,1.28N)/0.01N)
.EXTRACT FILE=Power label = pow119 (1.2*integ(I(v0),1.28N,1.29N)/0.01N)
.EXTRACT FILE=Power label = pow120 (1.2*integ(I(v0),1.29N,1.3N)/0.01N)
.EXTRACT FILE=Power label = pow121 (1.2*integ(I(v0),1.3N,1.31N)/0.01N)
.EXTRACT FILE=Power label = pow122 (1.2*integ(I(v0),1.31N,1.32N)/0.01N)
.EXTRACT FILE=Power label = pow123 (1.2*integ(I(v0),1.32N,1.33N)/0.01N)
.EXTRACT FILE=Power label = pow124 (1.2*integ(I(v0),1.33N,1.34N)/0.01N)
.EXTRACT FILE=Power label = pow125 (1.2*integ(I(v0),1.34N,1.35N)/0.01N)
.EXTRACT FILE=Power label = pow126 (1.2*integ(I(v0),1.35N,1.36N)/0.01N)
.EXTRACT FILE=Power label = pow127 (1.2*integ(I(v0),1.36N,1.37N)/0.01N)
.EXTRACT FILE=Power label = pow128 (1.2*integ(I(v0),1.37N,1.38N)/0.01N)
.EXTRACT FILE=Power label = pow129 (1.2*integ(I(v0),1.38N,1.39N)/0.01N)
.EXTRACT FILE=Power label = pow130 (1.2*integ(I(v0),1.39N,1.4N)/0.01N)
.EXTRACT FILE=Power label = pow131 (1.2*integ(I(v0),1.4N,1.41N)/0.01N)
.EXTRACT FILE=Power label = pow132 (1.2*integ(I(v0),1.41N,1.42N)/0.01N)
.EXTRACT FILE=Power label = pow133 (1.2*integ(I(v0),1.42N,1.43N)/0.01N)
.EXTRACT FILE=Power label = pow134 (1.2*integ(I(v0),1.43N,1.44N)/0.01N)
.EXTRACT FILE=Power label = pow135 (1.2*integ(I(v0),1.44N,1.45N)/0.01N)
.EXTRACT FILE=Power label = pow136 (1.2*integ(I(v0),1.45N,1.46N)/0.01N)
.EXTRACT FILE=Power label = pow137 (1.2*integ(I(v0),1.46N,1.47N)/0.01N)
.EXTRACT FILE=Power label = pow138 (1.2*integ(I(v0),1.47N,1.48N)/0.01N)
.EXTRACT FILE=Power label = pow139 (1.2*integ(I(v0),1.48N,1.49N)/0.01N)
.EXTRACT FILE=Power label = pow140 (1.2*integ(I(v0),1.49N,1.5N)/0.01N)
.EXTRACT FILE=Power label = pow141 (1.2*integ(I(v0),1.5N,1.51N)/0.01N)
.EXTRACT FILE=Power label = pow142 (1.2*integ(I(v0),1.51N,1.52N)/0.01N)
.EXTRACT FILE=Power label = pow143 (1.2*integ(I(v0),1.52N,1.53N)/0.01N)
.EXTRACT FILE=Power label = pow144 (1.2*integ(I(v0),1.53N,1.54N)/0.01N)
.EXTRACT FILE=Power label = pow145 (1.2*integ(I(v0),1.54N,1.55N)/0.01N)
.EXTRACT FILE=Power label = pow146 (1.2*integ(I(v0),1.55N,1.56N)/0.01N)
.EXTRACT FILE=Power label = pow147 (1.2*integ(I(v0),1.56N,1.57N)/0.01N)
.EXTRACT FILE=Power label = pow148 (1.2*integ(I(v0),1.57N,1.58N)/0.01N)
.EXTRACT FILE=Power label = pow149 (1.2*integ(I(v0),1.58N,1.59N)/0.01N)
.EXTRACT FILE=Power label = pow150 (1.2*integ(I(v0),1.59N,1.6N)/0.01N)
.EXTRACT FILE=Power label = pow151 (1.2*integ(I(v0),1.6N,1.61N)/0.01N)
.EXTRACT FILE=Power label = pow152 (1.2*integ(I(v0),1.61N,1.62N)/0.01N)
.EXTRACT FILE=Power label = pow153 (1.2*integ(I(v0),1.62N,1.63N)/0.01N)
.EXTRACT FILE=Power label = pow154 (1.2*integ(I(v0),1.63N,1.64N)/0.01N)
.EXTRACT FILE=Power label = pow155 (1.2*integ(I(v0),1.64N,1.65N)/0.01N)
.EXTRACT FILE=Power label = pow156 (1.2*integ(I(v0),1.65N,1.66N)/0.01N)
.EXTRACT FILE=Power label = pow157 (1.2*integ(I(v0),1.66N,1.67N)/0.01N)
.EXTRACT FILE=Power label = pow158 (1.2*integ(I(v0),1.67N,1.68N)/0.01N)
.EXTRACT FILE=Power label = pow159 (1.2*integ(I(v0),1.68N,1.69N)/0.01N)
.EXTRACT FILE=Power label = pow160 (1.2*integ(I(v0),1.69N,1.7N)/0.01N)
.EXTRACT FILE=Power label = pow161 (1.2*integ(I(v0),1.7N,1.71N)/0.01N)
.EXTRACT FILE=Power label = pow162 (1.2*integ(I(v0),1.71N,1.72N)/0.01N)
.EXTRACT FILE=Power label = pow163 (1.2*integ(I(v0),1.72N,1.73N)/0.01N)
.EXTRACT FILE=Power label = pow164 (1.2*integ(I(v0),1.73N,1.74N)/0.01N)
.EXTRACT FILE=Power label = pow165 (1.2*integ(I(v0),1.74N,1.75N)/0.01N)
.EXTRACT FILE=Power label = pow166 (1.2*integ(I(v0),1.75N,1.76N)/0.01N)
.EXTRACT FILE=Power label = pow167 (1.2*integ(I(v0),1.76N,1.77N)/0.01N)
.EXTRACT FILE=Power label = pow168 (1.2*integ(I(v0),1.77N,1.78N)/0.01N)
.EXTRACT FILE=Power label = pow169 (1.2*integ(I(v0),1.78N,1.79N)/0.01N)
.EXTRACT FILE=Power label = pow170 (1.2*integ(I(v0),1.79N,1.8N)/0.01N)
.EXTRACT FILE=Power label = pow171 (1.2*integ(I(v0),1.8N,1.81N)/0.01N)
.EXTRACT FILE=Power label = pow172 (1.2*integ(I(v0),1.81N,1.82N)/0.01N)
.EXTRACT FILE=Power label = pow173 (1.2*integ(I(v0),1.82N,1.83N)/0.01N)
.EXTRACT FILE=Power label = pow174 (1.2*integ(I(v0),1.83N,1.84N)/0.01N)
.EXTRACT FILE=Power label = pow175 (1.2*integ(I(v0),1.84N,1.85N)/0.01N)
.EXTRACT FILE=Power label = pow176 (1.2*integ(I(v0),1.85N,1.86N)/0.01N)
.EXTRACT FILE=Power label = pow177 (1.2*integ(I(v0),1.86N,1.87N)/0.01N)
.EXTRACT FILE=Power label = pow178 (1.2*integ(I(v0),1.87N,1.88N)/0.01N)
.EXTRACT FILE=Power label = pow179 (1.2*integ(I(v0),1.88N,1.89N)/0.01N)
.EXTRACT FILE=Power label = pow180 (1.2*integ(I(v0),1.89N,1.9N)/0.01N)
.EXTRACT FILE=Power label = pow181 (1.2*integ(I(v0),1.9N,1.91N)/0.01N)
.EXTRACT FILE=Power label = pow182 (1.2*integ(I(v0),1.91N,1.92N)/0.01N)
.EXTRACT FILE=Power label = pow183 (1.2*integ(I(v0),1.92N,1.93N)/0.01N)
.EXTRACT FILE=Power label = pow184 (1.2*integ(I(v0),1.93N,1.94N)/0.01N)
.EXTRACT FILE=Power label = pow185 (1.2*integ(I(v0),1.94N,1.95N)/0.01N)
.EXTRACT FILE=Power label = pow186 (1.2*integ(I(v0),1.95N,1.96N)/0.01N)
.EXTRACT FILE=Power label = pow187 (1.2*integ(I(v0),1.96N,1.97N)/0.01N)
.EXTRACT FILE=Power label = pow188 (1.2*integ(I(v0),1.97N,1.98N)/0.01N)
.EXTRACT FILE=Power label = pow189 (1.2*integ(I(v0),1.98N,1.99N)/0.01N)
.EXTRACT FILE=Power label = pow190 (1.2*integ(I(v0),1.99N,2.0N)/0.01N)
.EXTRACT FILE=Power label = pow191 (1.2*integ(I(v0),2.0N,2.01N)/0.01N)
.EXTRACT FILE=Power label = pow192 (1.2*integ(I(v0),2.01N,2.02N)/0.01N)
.EXTRACT FILE=Power label = pow193 (1.2*integ(I(v0),2.02N,2.03N)/0.01N)
.EXTRACT FILE=Power label = pow194 (1.2*integ(I(v0),2.03N,2.04N)/0.01N)
.EXTRACT FILE=Power label = pow195 (1.2*integ(I(v0),2.04N,2.05N)/0.01N)
.EXTRACT FILE=Power label = pow196 (1.2*integ(I(v0),2.05N,2.06N)/0.01N)
.EXTRACT FILE=Power label = pow197 (1.2*integ(I(v0),2.06N,2.07N)/0.01N)
.EXTRACT FILE=Power label = pow198 (1.2*integ(I(v0),2.07N,2.08N)/0.01N)
.EXTRACT FILE=Power label = pow199 (1.2*integ(I(v0),2.08N,2.09N)/0.01N)
.EXTRACT FILE=Power label = pow200 (1.2*integ(I(v0),2.09N,2.1N)/0.01N)
.EXTRACT FILE=Power label = pow201 (1.2*integ(I(v0),2.1N,2.11N)/0.01N)
.EXTRACT FILE=Power label = pow202 (1.2*integ(I(v0),2.11N,2.12N)/0.01N)
.EXTRACT FILE=Power label = pow203 (1.2*integ(I(v0),2.12N,2.13N)/0.01N)
.EXTRACT FILE=Power label = pow204 (1.2*integ(I(v0),2.13N,2.14N)/0.01N)
.EXTRACT FILE=Power label = pow205 (1.2*integ(I(v0),2.14N,2.15N)/0.01N)
.EXTRACT FILE=Power label = pow206 (1.2*integ(I(v0),2.15N,2.16N)/0.01N)
.EXTRACT FILE=Power label = pow207 (1.2*integ(I(v0),2.16N,2.17N)/0.01N)
.EXTRACT FILE=Power label = pow208 (1.2*integ(I(v0),2.17N,2.18N)/0.01N)
.EXTRACT FILE=Power label = pow209 (1.2*integ(I(v0),2.18N,2.19N)/0.01N)
.EXTRACT FILE=Power label = pow210 (1.2*integ(I(v0),2.19N,2.2N)/0.01N)
.EXTRACT FILE=Power label = pow211 (1.2*integ(I(v0),2.2N,2.21N)/0.01N)
.EXTRACT FILE=Power label = pow212 (1.2*integ(I(v0),2.21N,2.22N)/0.01N)
.EXTRACT FILE=Power label = pow213 (1.2*integ(I(v0),2.22N,2.23N)/0.01N)
.EXTRACT FILE=Power label = pow214 (1.2*integ(I(v0),2.23N,2.24N)/0.01N)
.EXTRACT FILE=Power label = pow215 (1.2*integ(I(v0),2.24N,2.25N)/0.01N)
.EXTRACT FILE=Power label = pow216 (1.2*integ(I(v0),2.25N,2.26N)/0.01N)
.EXTRACT FILE=Power label = pow217 (1.2*integ(I(v0),2.26N,2.27N)/0.01N)
.EXTRACT FILE=Power label = pow218 (1.2*integ(I(v0),2.27N,2.28N)/0.01N)
.EXTRACT FILE=Power label = pow219 (1.2*integ(I(v0),2.28N,2.29N)/0.01N)
.EXTRACT FILE=Power label = pow220 (1.2*integ(I(v0),2.29N,2.3N)/0.01N)
.EXTRACT FILE=Power label = pow221 (1.2*integ(I(v0),2.3N,2.31N)/0.01N)
.EXTRACT FILE=Power label = pow222 (1.2*integ(I(v0),2.31N,2.32N)/0.01N)
.EXTRACT FILE=Power label = pow223 (1.2*integ(I(v0),2.32N,2.33N)/0.01N)
.EXTRACT FILE=Power label = pow224 (1.2*integ(I(v0),2.33N,2.34N)/0.01N)
.EXTRACT FILE=Power label = pow225 (1.2*integ(I(v0),2.34N,2.35N)/0.01N)
.EXTRACT FILE=Power label = pow226 (1.2*integ(I(v0),2.35N,2.36N)/0.01N)
.EXTRACT FILE=Power label = pow227 (1.2*integ(I(v0),2.36N,2.37N)/0.01N)
.EXTRACT FILE=Power label = pow228 (1.2*integ(I(v0),2.37N,2.38N)/0.01N)
.EXTRACT FILE=Power label = pow229 (1.2*integ(I(v0),2.38N,2.39N)/0.01N)
.EXTRACT FILE=Power label = pow230 (1.2*integ(I(v0),2.39N,2.4N)/0.01N)
.EXTRACT FILE=Power label = pow231 (1.2*integ(I(v0),2.4N,2.41N)/0.01N)
.EXTRACT FILE=Power label = pow232 (1.2*integ(I(v0),2.41N,2.42N)/0.01N)
.EXTRACT FILE=Power label = pow233 (1.2*integ(I(v0),2.42N,2.43N)/0.01N)
.EXTRACT FILE=Power label = pow234 (1.2*integ(I(v0),2.43N,2.44N)/0.01N)
.EXTRACT FILE=Power label = pow235 (1.2*integ(I(v0),2.44N,2.45N)/0.01N)
.EXTRACT FILE=Power label = pow236 (1.2*integ(I(v0),2.45N,2.46N)/0.01N)
.EXTRACT FILE=Power label = pow237 (1.2*integ(I(v0),2.46N,2.47N)/0.01N)
.EXTRACT FILE=Power label = pow238 (1.2*integ(I(v0),2.47N,2.48N)/0.01N)
.EXTRACT FILE=Power label = pow239 (1.2*integ(I(v0),2.48N,2.49N)/0.01N)
.EXTRACT FILE=Power label = pow240 (1.2*integ(I(v0),2.49N,2.5N)/0.01N)
.EXTRACT FILE=Power label = pow241 (1.2*integ(I(v0),2.5N,2.51N)/0.01N)
.EXTRACT FILE=Power label = pow242 (1.2*integ(I(v0),2.51N,2.52N)/0.01N)
.EXTRACT FILE=Power label = pow243 (1.2*integ(I(v0),2.52N,2.53N)/0.01N)
.EXTRACT FILE=Power label = pow244 (1.2*integ(I(v0),2.53N,2.54N)/0.01N)
.EXTRACT FILE=Power label = pow245 (1.2*integ(I(v0),2.54N,2.55N)/0.01N)
.EXTRACT FILE=Power label = pow246 (1.2*integ(I(v0),2.55N,2.56N)/0.01N)
.EXTRACT FILE=Power label = pow247 (1.2*integ(I(v0),2.56N,2.57N)/0.01N)
.EXTRACT FILE=Power label = pow248 (1.2*integ(I(v0),2.57N,2.58N)/0.01N)
.EXTRACT FILE=Power label = pow249 (1.2*integ(I(v0),2.58N,2.59N)/0.01N)
.EXTRACT FILE=Power label = pow250 (1.2*integ(I(v0),2.59N,2.6N)/0.01N)
.EXTRACT FILE=Power label = pow251 (1.2*integ(I(v0),2.6N,2.61N)/0.01N)
.EXTRACT FILE=Power label = pow252 (1.2*integ(I(v0),2.61N,2.62N)/0.01N)
.EXTRACT FILE=Power label = pow253 (1.2*integ(I(v0),2.62N,2.63N)/0.01N)
.EXTRACT FILE=Power label = pow254 (1.2*integ(I(v0),2.63N,2.64N)/0.01N)
.EXTRACT FILE=Power label = pow255 (1.2*integ(I(v0),2.64N,2.65N)/0.01N)
.EXTRACT FILE=Power label = pow256 (1.2*integ(I(v0),2.65N,2.66N)/0.01N)
.EXTRACT FILE=Power label = pow257 (1.2*integ(I(v0),2.66N,2.67N)/0.01N)
.EXTRACT FILE=Power label = pow258 (1.2*integ(I(v0),2.67N,2.68N)/0.01N)
.EXTRACT FILE=Power label = pow259 (1.2*integ(I(v0),2.68N,2.69N)/0.01N)
.EXTRACT FILE=Power label = pow260 (1.2*integ(I(v0),2.69N,2.7N)/0.01N)
.EXTRACT FILE=Power label = pow261 (1.2*integ(I(v0),2.7N,2.71N)/0.01N)
.EXTRACT FILE=Power label = pow262 (1.2*integ(I(v0),2.71N,2.72N)/0.01N)
.EXTRACT FILE=Power label = pow263 (1.2*integ(I(v0),2.72N,2.73N)/0.01N)
.EXTRACT FILE=Power label = pow264 (1.2*integ(I(v0),2.73N,2.74N)/0.01N)
.EXTRACT FILE=Power label = pow265 (1.2*integ(I(v0),2.74N,2.75N)/0.01N)
.EXTRACT FILE=Power label = pow266 (1.2*integ(I(v0),2.75N,2.76N)/0.01N)
.EXTRACT FILE=Power label = pow267 (1.2*integ(I(v0),2.76N,2.77N)/0.01N)
.EXTRACT FILE=Power label = pow268 (1.2*integ(I(v0),2.77N,2.78N)/0.01N)
.EXTRACT FILE=Power label = pow269 (1.2*integ(I(v0),2.78N,2.79N)/0.01N)
.EXTRACT FILE=Power label = pow270 (1.2*integ(I(v0),2.79N,2.8N)/0.01N)
.EXTRACT FILE=Power label = pow271 (1.2*integ(I(v0),2.8N,2.81N)/0.01N)
.EXTRACT FILE=Power label = pow272 (1.2*integ(I(v0),2.81N,2.82N)/0.01N)
.EXTRACT FILE=Power label = pow273 (1.2*integ(I(v0),2.82N,2.83N)/0.01N)
.EXTRACT FILE=Power label = pow274 (1.2*integ(I(v0),2.83N,2.84N)/0.01N)
.EXTRACT FILE=Power label = pow275 (1.2*integ(I(v0),2.84N,2.85N)/0.01N)
.EXTRACT FILE=Power label = pow276 (1.2*integ(I(v0),2.85N,2.86N)/0.01N)
.EXTRACT FILE=Power label = pow277 (1.2*integ(I(v0),2.86N,2.87N)/0.01N)
.EXTRACT FILE=Power label = pow278 (1.2*integ(I(v0),2.87N,2.88N)/0.01N)
.EXTRACT FILE=Power label = pow279 (1.2*integ(I(v0),2.88N,2.89N)/0.01N)
.EXTRACT FILE=Power label = pow280 (1.2*integ(I(v0),2.89N,2.9N)/0.01N)
.EXTRACT FILE=Power label = pow281 (1.2*integ(I(v0),2.9N,2.91N)/0.01N)
.EXTRACT FILE=Power label = pow282 (1.2*integ(I(v0),2.91N,2.92N)/0.01N)
.EXTRACT FILE=Power label = pow283 (1.2*integ(I(v0),2.92N,2.93N)/0.01N)
.EXTRACT FILE=Power label = pow284 (1.2*integ(I(v0),2.93N,2.94N)/0.01N)
.EXTRACT FILE=Power label = pow285 (1.2*integ(I(v0),2.94N,2.95N)/0.01N)
.EXTRACT FILE=Power label = pow286 (1.2*integ(I(v0),2.95N,2.96N)/0.01N)
.EXTRACT FILE=Power label = pow287 (1.2*integ(I(v0),2.96N,2.97N)/0.01N)
.EXTRACT FILE=Power label = pow288 (1.2*integ(I(v0),2.97N,2.98N)/0.01N)
.EXTRACT FILE=Power label = pow289 (1.2*integ(I(v0),2.98N,2.99N)/0.01N)
.EXTRACT FILE=Power label = pow290 (1.2*integ(I(v0),2.99N,3.0N)/0.01N)
.EXTRACT FILE=Power label = pow291 (1.2*integ(I(v0),3.0N,3.01N)/0.01N)
.EXTRACT FILE=Power label = pow292 (1.2*integ(I(v0),3.01N,3.02N)/0.01N)
.EXTRACT FILE=Power label = pow293 (1.2*integ(I(v0),3.02N,3.03N)/0.01N)
.EXTRACT FILE=Power label = pow294 (1.2*integ(I(v0),3.03N,3.04N)/0.01N)
.EXTRACT FILE=Power label = pow295 (1.2*integ(I(v0),3.04N,3.05N)/0.01N)
.EXTRACT FILE=Power label = pow296 (1.2*integ(I(v0),3.05N,3.06N)/0.01N)
.EXTRACT FILE=Power label = pow297 (1.2*integ(I(v0),3.06N,3.07N)/0.01N)
.EXTRACT FILE=Power label = pow298 (1.2*integ(I(v0),3.07N,3.08N)/0.01N)
.EXTRACT FILE=Power label = pow299 (1.2*integ(I(v0),3.08N,3.09N)/0.01N)
.EXTRACT FILE=Power label = pow300 (1.2*integ(I(v0),3.09N,3.1N)/0.01N)
.EXTRACT FILE=Power label = pow301 (1.2*integ(I(v0),3.1N,3.11N)/0.01N)
.EXTRACT FILE=Power label = pow302 (1.2*integ(I(v0),3.11N,3.12N)/0.01N)
.EXTRACT FILE=Power label = pow303 (1.2*integ(I(v0),3.12N,3.13N)/0.01N)
.EXTRACT FILE=Power label = pow304 (1.2*integ(I(v0),3.13N,3.14N)/0.01N)
.EXTRACT FILE=Power label = pow305 (1.2*integ(I(v0),3.14N,3.15N)/0.01N)
.EXTRACT FILE=Power label = pow306 (1.2*integ(I(v0),3.15N,3.16N)/0.01N)
.EXTRACT FILE=Power label = pow307 (1.2*integ(I(v0),3.16N,3.17N)/0.01N)
.EXTRACT FILE=Power label = pow308 (1.2*integ(I(v0),3.17N,3.18N)/0.01N)
.EXTRACT FILE=Power label = pow309 (1.2*integ(I(v0),3.18N,3.19N)/0.01N)
.EXTRACT FILE=Power label = pow310 (1.2*integ(I(v0),3.19N,3.2N)/0.01N)
.EXTRACT FILE=Power label = pow311 (1.2*integ(I(v0),3.2N,3.21N)/0.01N)
.EXTRACT FILE=Power label = pow312 (1.2*integ(I(v0),3.21N,3.22N)/0.01N)
.EXTRACT FILE=Power label = pow313 (1.2*integ(I(v0),3.22N,3.23N)/0.01N)
.EXTRACT FILE=Power label = pow314 (1.2*integ(I(v0),3.23N,3.24N)/0.01N)
.EXTRACT FILE=Power label = pow315 (1.2*integ(I(v0),3.24N,3.25N)/0.01N)
.EXTRACT FILE=Power label = pow316 (1.2*integ(I(v0),3.25N,3.26N)/0.01N)
.EXTRACT FILE=Power label = pow317 (1.2*integ(I(v0),3.26N,3.27N)/0.01N)
.EXTRACT FILE=Power label = pow318 (1.2*integ(I(v0),3.27N,3.28N)/0.01N)
.EXTRACT FILE=Power label = pow319 (1.2*integ(I(v0),3.28N,3.29N)/0.01N)
.EXTRACT FILE=Power label = pow320 (1.2*integ(I(v0),3.29N,3.3N)/0.01N)
.EXTRACT FILE=Power label = pow321 (1.2*integ(I(v0),3.3N,3.31N)/0.01N)
.EXTRACT FILE=Power label = pow322 (1.2*integ(I(v0),3.31N,3.32N)/0.01N)
.EXTRACT FILE=Power label = pow323 (1.2*integ(I(v0),3.32N,3.33N)/0.01N)
.EXTRACT FILE=Power label = pow324 (1.2*integ(I(v0),3.33N,3.34N)/0.01N)
.EXTRACT FILE=Power label = pow325 (1.2*integ(I(v0),3.34N,3.35N)/0.01N)
.EXTRACT FILE=Power label = pow326 (1.2*integ(I(v0),3.35N,3.36N)/0.01N)
.EXTRACT FILE=Power label = pow327 (1.2*integ(I(v0),3.36N,3.37N)/0.01N)
.EXTRACT FILE=Power label = pow328 (1.2*integ(I(v0),3.37N,3.38N)/0.01N)
.EXTRACT FILE=Power label = pow329 (1.2*integ(I(v0),3.38N,3.39N)/0.01N)
.EXTRACT FILE=Power label = pow330 (1.2*integ(I(v0),3.39N,3.4N)/0.01N)
.EXTRACT FILE=Power label = pow331 (1.2*integ(I(v0),3.4N,3.41N)/0.01N)
.EXTRACT FILE=Power label = pow332 (1.2*integ(I(v0),3.41N,3.42N)/0.01N)
.EXTRACT FILE=Power label = pow333 (1.2*integ(I(v0),3.42N,3.43N)/0.01N)
.EXTRACT FILE=Power label = pow334 (1.2*integ(I(v0),3.43N,3.44N)/0.01N)
.EXTRACT FILE=Power label = pow335 (1.2*integ(I(v0),3.44N,3.45N)/0.01N)
.EXTRACT FILE=Power label = pow336 (1.2*integ(I(v0),3.45N,3.46N)/0.01N)
.EXTRACT FILE=Power label = pow337 (1.2*integ(I(v0),3.46N,3.47N)/0.01N)
.EXTRACT FILE=Power label = pow338 (1.2*integ(I(v0),3.47N,3.48N)/0.01N)
.EXTRACT FILE=Power label = pow339 (1.2*integ(I(v0),3.48N,3.49N)/0.01N)
.EXTRACT FILE=Power label = pow340 (1.2*integ(I(v0),3.49N,3.5N)/0.01N)
.EXTRACT FILE=Power label = pow341 (1.2*integ(I(v0),3.5N,3.51N)/0.01N)
.EXTRACT FILE=Power label = pow342 (1.2*integ(I(v0),3.51N,3.52N)/0.01N)
.EXTRACT FILE=Power label = pow343 (1.2*integ(I(v0),3.52N,3.53N)/0.01N)
.EXTRACT FILE=Power label = pow344 (1.2*integ(I(v0),3.53N,3.54N)/0.01N)
.EXTRACT FILE=Power label = pow345 (1.2*integ(I(v0),3.54N,3.55N)/0.01N)
.EXTRACT FILE=Power label = pow346 (1.2*integ(I(v0),3.55N,3.56N)/0.01N)
.EXTRACT FILE=Power label = pow347 (1.2*integ(I(v0),3.56N,3.57N)/0.01N)
.EXTRACT FILE=Power label = pow348 (1.2*integ(I(v0),3.57N,3.58N)/0.01N)
.EXTRACT FILE=Power label = pow349 (1.2*integ(I(v0),3.58N,3.59N)/0.01N)
.EXTRACT FILE=Power label = pow350 (1.2*integ(I(v0),3.59N,3.6N)/0.01N)
.EXTRACT FILE=Power label = pow351 (1.2*integ(I(v0),3.6N,3.61N)/0.01N)
.EXTRACT FILE=Power label = pow352 (1.2*integ(I(v0),3.61N,3.62N)/0.01N)
.EXTRACT FILE=Power label = pow353 (1.2*integ(I(v0),3.62N,3.63N)/0.01N)
.EXTRACT FILE=Power label = pow354 (1.2*integ(I(v0),3.63N,3.64N)/0.01N)
.EXTRACT FILE=Power label = pow355 (1.2*integ(I(v0),3.64N,3.65N)/0.01N)
.EXTRACT FILE=Power label = pow356 (1.2*integ(I(v0),3.65N,3.66N)/0.01N)
.EXTRACT FILE=Power label = pow357 (1.2*integ(I(v0),3.66N,3.67N)/0.01N)
.EXTRACT FILE=Power label = pow358 (1.2*integ(I(v0),3.67N,3.68N)/0.01N)
.EXTRACT FILE=Power label = pow359 (1.2*integ(I(v0),3.68N,3.69N)/0.01N)
.EXTRACT FILE=Power label = pow360 (1.2*integ(I(v0),3.69N,3.7N)/0.01N)
.EXTRACT FILE=Power label = pow361 (1.2*integ(I(v0),3.7N,3.71N)/0.01N)
.EXTRACT FILE=Power label = pow362 (1.2*integ(I(v0),3.71N,3.72N)/0.01N)
.EXTRACT FILE=Power label = pow363 (1.2*integ(I(v0),3.72N,3.73N)/0.01N)
.EXTRACT FILE=Power label = pow364 (1.2*integ(I(v0),3.73N,3.74N)/0.01N)
.EXTRACT FILE=Power label = pow365 (1.2*integ(I(v0),3.74N,3.75N)/0.01N)
.EXTRACT FILE=Power label = pow366 (1.2*integ(I(v0),3.75N,3.76N)/0.01N)
.EXTRACT FILE=Power label = pow367 (1.2*integ(I(v0),3.76N,3.77N)/0.01N)
.EXTRACT FILE=Power label = pow368 (1.2*integ(I(v0),3.77N,3.78N)/0.01N)
.EXTRACT FILE=Power label = pow369 (1.2*integ(I(v0),3.78N,3.79N)/0.01N)
.EXTRACT FILE=Power label = pow370 (1.2*integ(I(v0),3.79N,3.8N)/0.01N)
.EXTRACT FILE=Power label = pow371 (1.2*integ(I(v0),3.8N,3.81N)/0.01N)
.EXTRACT FILE=Power label = pow372 (1.2*integ(I(v0),3.81N,3.82N)/0.01N)
.EXTRACT FILE=Power label = pow373 (1.2*integ(I(v0),3.82N,3.83N)/0.01N)
.EXTRACT FILE=Power label = pow374 (1.2*integ(I(v0),3.83N,3.84N)/0.01N)
.EXTRACT FILE=Power label = pow375 (1.2*integ(I(v0),3.84N,3.85N)/0.01N)
.EXTRACT FILE=Power label = pow376 (1.2*integ(I(v0),3.85N,3.86N)/0.01N)
.EXTRACT FILE=Power label = pow377 (1.2*integ(I(v0),3.86N,3.87N)/0.01N)
.EXTRACT FILE=Power label = pow378 (1.2*integ(I(v0),3.87N,3.88N)/0.01N)
.EXTRACT FILE=Power label = pow379 (1.2*integ(I(v0),3.88N,3.89N)/0.01N)
.EXTRACT FILE=Power label = pow380 (1.2*integ(I(v0),3.89N,3.9N)/0.01N)
.EXTRACT FILE=Power label = pow381 (1.2*integ(I(v0),3.9N,3.91N)/0.01N)
.EXTRACT FILE=Power label = pow382 (1.2*integ(I(v0),3.91N,3.92N)/0.01N)
.EXTRACT FILE=Power label = pow383 (1.2*integ(I(v0),3.92N,3.93N)/0.01N)
.EXTRACT FILE=Power label = pow384 (1.2*integ(I(v0),3.93N,3.94N)/0.01N)
.EXTRACT FILE=Power label = pow385 (1.2*integ(I(v0),3.94N,3.95N)/0.01N)
.EXTRACT FILE=Power label = pow386 (1.2*integ(I(v0),3.95N,3.96N)/0.01N)
.EXTRACT FILE=Power label = pow387 (1.2*integ(I(v0),3.96N,3.97N)/0.01N)
.EXTRACT FILE=Power label = pow388 (1.2*integ(I(v0),3.97N,3.98N)/0.01N)
.EXTRACT FILE=Power label = pow389 (1.2*integ(I(v0),3.98N,3.99N)/0.01N)
.EXTRACT FILE=Power label = pow390 (1.2*integ(I(v0),3.99N,4.0N)/0.01N)
.EXTRACT FILE=Power label = pow391 (1.2*integ(I(v0),4.0N,4.01N)/0.01N)
.EXTRACT FILE=Power label = pow392 (1.2*integ(I(v0),4.01N,4.02N)/0.01N)
.EXTRACT FILE=Power label = pow393 (1.2*integ(I(v0),4.02N,4.03N)/0.01N)
.EXTRACT FILE=Power label = pow394 (1.2*integ(I(v0),4.03N,4.04N)/0.01N)
.EXTRACT FILE=Power label = pow395 (1.2*integ(I(v0),4.04N,4.05N)/0.01N)
.EXTRACT FILE=Power label = pow396 (1.2*integ(I(v0),4.05N,4.06N)/0.01N)
.EXTRACT FILE=Power label = pow397 (1.2*integ(I(v0),4.06N,4.07N)/0.01N)
.EXTRACT FILE=Power label = pow398 (1.2*integ(I(v0),4.07N,4.08N)/0.01N)
.EXTRACT FILE=Power label = pow399 (1.2*integ(I(v0),4.08N,4.09N)/0.01N)
.EXTRACT FILE=Power label = pow400 (1.2*integ(I(v0),4.09N,4.1N)/0.01N)
.EXTRACT FILE=Power label = pow401 (1.2*integ(I(v0),4.1N,4.11N)/0.01N)
.EXTRACT FILE=Power label = pow402 (1.2*integ(I(v0),4.11N,4.12N)/0.01N)
.EXTRACT FILE=Power label = pow403 (1.2*integ(I(v0),4.12N,4.13N)/0.01N)
.EXTRACT FILE=Power label = pow404 (1.2*integ(I(v0),4.13N,4.14N)/0.01N)
.EXTRACT FILE=Power label = pow405 (1.2*integ(I(v0),4.14N,4.15N)/0.01N)
.EXTRACT FILE=Power label = pow406 (1.2*integ(I(v0),4.15N,4.16N)/0.01N)
.EXTRACT FILE=Power label = pow407 (1.2*integ(I(v0),4.16N,4.17N)/0.01N)
.EXTRACT FILE=Power label = pow408 (1.2*integ(I(v0),4.17N,4.18N)/0.01N)
.EXTRACT FILE=Power label = pow409 (1.2*integ(I(v0),4.18N,4.19N)/0.01N)
.EXTRACT FILE=Power label = pow410 (1.2*integ(I(v0),4.19N,4.2N)/0.01N)
.EXTRACT FILE=Power label = pow411 (1.2*integ(I(v0),4.2N,4.21N)/0.01N)
.EXTRACT FILE=Power label = pow412 (1.2*integ(I(v0),4.21N,4.22N)/0.01N)
.EXTRACT FILE=Power label = pow413 (1.2*integ(I(v0),4.22N,4.23N)/0.01N)
.EXTRACT FILE=Power label = pow414 (1.2*integ(I(v0),4.23N,4.24N)/0.01N)
.EXTRACT FILE=Power label = pow415 (1.2*integ(I(v0),4.24N,4.25N)/0.01N)
.EXTRACT FILE=Power label = pow416 (1.2*integ(I(v0),4.25N,4.26N)/0.01N)
.EXTRACT FILE=Power label = pow417 (1.2*integ(I(v0),4.26N,4.27N)/0.01N)
.EXTRACT FILE=Power label = pow418 (1.2*integ(I(v0),4.27N,4.28N)/0.01N)
.EXTRACT FILE=Power label = pow419 (1.2*integ(I(v0),4.28N,4.29N)/0.01N)
.EXTRACT FILE=Power label = pow420 (1.2*integ(I(v0),4.29N,4.3N)/0.01N)
.EXTRACT FILE=Power label = pow421 (1.2*integ(I(v0),4.3N,4.31N)/0.01N)
.EXTRACT FILE=Power label = pow422 (1.2*integ(I(v0),4.31N,4.32N)/0.01N)
.EXTRACT FILE=Power label = pow423 (1.2*integ(I(v0),4.32N,4.33N)/0.01N)
.EXTRACT FILE=Power label = pow424 (1.2*integ(I(v0),4.33N,4.34N)/0.01N)
.EXTRACT FILE=Power label = pow425 (1.2*integ(I(v0),4.34N,4.35N)/0.01N)
.EXTRACT FILE=Power label = pow426 (1.2*integ(I(v0),4.35N,4.36N)/0.01N)
.EXTRACT FILE=Power label = pow427 (1.2*integ(I(v0),4.36N,4.37N)/0.01N)
.EXTRACT FILE=Power label = pow428 (1.2*integ(I(v0),4.37N,4.38N)/0.01N)
.EXTRACT FILE=Power label = pow429 (1.2*integ(I(v0),4.38N,4.39N)/0.01N)
.EXTRACT FILE=Power label = pow430 (1.2*integ(I(v0),4.39N,4.4N)/0.01N)
.EXTRACT FILE=Power label = pow431 (1.2*integ(I(v0),4.4N,4.41N)/0.01N)
.EXTRACT FILE=Power label = pow432 (1.2*integ(I(v0),4.41N,4.42N)/0.01N)
.EXTRACT FILE=Power label = pow433 (1.2*integ(I(v0),4.42N,4.43N)/0.01N)
.EXTRACT FILE=Power label = pow434 (1.2*integ(I(v0),4.43N,4.44N)/0.01N)
.EXTRACT FILE=Power label = pow435 (1.2*integ(I(v0),4.44N,4.45N)/0.01N)
.EXTRACT FILE=Power label = pow436 (1.2*integ(I(v0),4.45N,4.46N)/0.01N)
.EXTRACT FILE=Power label = pow437 (1.2*integ(I(v0),4.46N,4.47N)/0.01N)
.EXTRACT FILE=Power label = pow438 (1.2*integ(I(v0),4.47N,4.48N)/0.01N)
.EXTRACT FILE=Power label = pow439 (1.2*integ(I(v0),4.48N,4.49N)/0.01N)
.EXTRACT FILE=Power label = pow440 (1.2*integ(I(v0),4.49N,4.5N)/0.01N)
.EXTRACT FILE=Power label = pow441 (1.2*integ(I(v0),4.5N,4.51N)/0.01N)
.EXTRACT FILE=Power label = pow442 (1.2*integ(I(v0),4.51N,4.52N)/0.01N)
.EXTRACT FILE=Power label = pow443 (1.2*integ(I(v0),4.52N,4.53N)/0.01N)
.EXTRACT FILE=Power label = pow444 (1.2*integ(I(v0),4.53N,4.54N)/0.01N)
.EXTRACT FILE=Power label = pow445 (1.2*integ(I(v0),4.54N,4.55N)/0.01N)
.EXTRACT FILE=Power label = pow446 (1.2*integ(I(v0),4.55N,4.56N)/0.01N)
.EXTRACT FILE=Power label = pow447 (1.2*integ(I(v0),4.56N,4.57N)/0.01N)
.EXTRACT FILE=Power label = pow448 (1.2*integ(I(v0),4.57N,4.58N)/0.01N)
.EXTRACT FILE=Power label = pow449 (1.2*integ(I(v0),4.58N,4.59N)/0.01N)
.EXTRACT FILE=Power label = pow450 (1.2*integ(I(v0),4.59N,4.6N)/0.01N)
.EXTRACT FILE=Power label = pow451 (1.2*integ(I(v0),4.6N,4.61N)/0.01N)
.EXTRACT FILE=Power label = pow452 (1.2*integ(I(v0),4.61N,4.62N)/0.01N)
.EXTRACT FILE=Power label = pow453 (1.2*integ(I(v0),4.62N,4.63N)/0.01N)
.EXTRACT FILE=Power label = pow454 (1.2*integ(I(v0),4.63N,4.64N)/0.01N)
.EXTRACT FILE=Power label = pow455 (1.2*integ(I(v0),4.64N,4.65N)/0.01N)
.EXTRACT FILE=Power label = pow456 (1.2*integ(I(v0),4.65N,4.66N)/0.01N)
.EXTRACT FILE=Power label = pow457 (1.2*integ(I(v0),4.66N,4.67N)/0.01N)
.EXTRACT FILE=Power label = pow458 (1.2*integ(I(v0),4.67N,4.68N)/0.01N)
.EXTRACT FILE=Power label = pow459 (1.2*integ(I(v0),4.68N,4.69N)/0.01N)
.EXTRACT FILE=Power label = pow460 (1.2*integ(I(v0),4.69N,4.7N)/0.01N)
.EXTRACT FILE=Power label = pow461 (1.2*integ(I(v0),4.7N,4.71N)/0.01N)
.EXTRACT FILE=Power label = pow462 (1.2*integ(I(v0),4.71N,4.72N)/0.01N)
.EXTRACT FILE=Power label = pow463 (1.2*integ(I(v0),4.72N,4.73N)/0.01N)
.EXTRACT FILE=Power label = pow464 (1.2*integ(I(v0),4.73N,4.74N)/0.01N)
.EXTRACT FILE=Power label = pow465 (1.2*integ(I(v0),4.74N,4.75N)/0.01N)
.EXTRACT FILE=Power label = pow466 (1.2*integ(I(v0),4.75N,4.76N)/0.01N)
.EXTRACT FILE=Power label = pow467 (1.2*integ(I(v0),4.76N,4.77N)/0.01N)
.EXTRACT FILE=Power label = pow468 (1.2*integ(I(v0),4.77N,4.78N)/0.01N)
.EXTRACT FILE=Power label = pow469 (1.2*integ(I(v0),4.78N,4.79N)/0.01N)
.EXTRACT FILE=Power label = pow470 (1.2*integ(I(v0),4.79N,4.8N)/0.01N)
.EXTRACT FILE=Power label = pow471 (1.2*integ(I(v0),4.8N,4.81N)/0.01N)
.EXTRACT FILE=Power label = pow472 (1.2*integ(I(v0),4.81N,4.82N)/0.01N)
.EXTRACT FILE=Power label = pow473 (1.2*integ(I(v0),4.82N,4.83N)/0.01N)
.EXTRACT FILE=Power label = pow474 (1.2*integ(I(v0),4.83N,4.84N)/0.01N)
.EXTRACT FILE=Power label = pow475 (1.2*integ(I(v0),4.84N,4.85N)/0.01N)
.EXTRACT FILE=Power label = pow476 (1.2*integ(I(v0),4.85N,4.86N)/0.01N)
.EXTRACT FILE=Power label = pow477 (1.2*integ(I(v0),4.86N,4.87N)/0.01N)
.EXTRACT FILE=Power label = pow478 (1.2*integ(I(v0),4.87N,4.88N)/0.01N)
.EXTRACT FILE=Power label = pow479 (1.2*integ(I(v0),4.88N,4.89N)/0.01N)
.EXTRACT FILE=Power label = pow480 (1.2*integ(I(v0),4.89N,4.9N)/0.01N)
.EXTRACT FILE=Power label = pow481 (1.2*integ(I(v0),4.9N,4.91N)/0.01N)
.EXTRACT FILE=Power label = pow482 (1.2*integ(I(v0),4.91N,4.92N)/0.01N)
.EXTRACT FILE=Power label = pow483 (1.2*integ(I(v0),4.92N,4.93N)/0.01N)
.EXTRACT FILE=Power label = pow484 (1.2*integ(I(v0),4.93N,4.94N)/0.01N)
.EXTRACT FILE=Power label = pow485 (1.2*integ(I(v0),4.94N,4.95N)/0.01N)
.EXTRACT FILE=Power label = pow486 (1.2*integ(I(v0),4.95N,4.96N)/0.01N)
.EXTRACT FILE=Power label = pow487 (1.2*integ(I(v0),4.96N,4.97N)/0.01N)
.EXTRACT FILE=Power label = pow488 (1.2*integ(I(v0),4.97N,4.98N)/0.01N)
.EXTRACT FILE=Power label = pow489 (1.2*integ(I(v0),4.98N,4.99N)/0.01N)
.EXTRACT FILE=Power label = pow490 (1.2*integ(I(v0),4.99N,5.0N)/0.01N)
.EXTRACT FILE=Power label = pow491 (1.2*integ(I(v0),5.0N,5.01N)/0.01N)
.EXTRACT FILE=Power label = pow492 (1.2*integ(I(v0),5.01N,5.02N)/0.01N)
.EXTRACT FILE=Power label = pow493 (1.2*integ(I(v0),5.02N,5.03N)/0.01N)
.EXTRACT FILE=Power label = pow494 (1.2*integ(I(v0),5.03N,5.04N)/0.01N)
.EXTRACT FILE=Power label = pow495 (1.2*integ(I(v0),5.04N,5.05N)/0.01N)
.EXTRACT FILE=Power label = pow496 (1.2*integ(I(v0),5.05N,5.06N)/0.01N)
.EXTRACT FILE=Power label = pow497 (1.2*integ(I(v0),5.06N,5.07N)/0.01N)
.EXTRACT FILE=Power label = pow498 (1.2*integ(I(v0),5.07N,5.08N)/0.01N)
.EXTRACT FILE=Power label = pow499 (1.2*integ(I(v0),5.08N,5.09N)/0.01N)
.EXTRACT FILE=Power label = pow500 (1.2*integ(I(v0),5.09N,5.1N)/0.01N)
.EXTRACT FILE=Power label = pow501 (1.2*integ(I(v0),5.1N,5.11N)/0.01N)
.EXTRACT FILE=Power label = pow502 (1.2*integ(I(v0),5.11N,5.12N)/0.01N)
.EXTRACT FILE=Power label = pow503 (1.2*integ(I(v0),5.12N,5.13N)/0.01N)
.EXTRACT FILE=Power label = pow504 (1.2*integ(I(v0),5.13N,5.14N)/0.01N)
.EXTRACT FILE=Power label = pow505 (1.2*integ(I(v0),5.14N,5.15N)/0.01N)
.EXTRACT FILE=Power label = pow506 (1.2*integ(I(v0),5.15N,5.16N)/0.01N)
.EXTRACT FILE=Power label = pow507 (1.2*integ(I(v0),5.16N,5.17N)/0.01N)
.EXTRACT FILE=Power label = pow508 (1.2*integ(I(v0),5.17N,5.18N)/0.01N)
.EXTRACT FILE=Power label = pow509 (1.2*integ(I(v0),5.18N,5.19N)/0.01N)
.EXTRACT FILE=Power label = pow510 (1.2*integ(I(v0),5.19N,5.2N)/0.01N)
.EXTRACT FILE=Power label = pow511 (1.2*integ(I(v0),5.2N,5.21N)/0.01N)
.EXTRACT FILE=Power label = pow512 (1.2*integ(I(v0),5.21N,5.22N)/0.01N)
.EXTRACT FILE=Power label = pow513 (1.2*integ(I(v0),5.22N,5.23N)/0.01N)
.EXTRACT FILE=Power label = pow514 (1.2*integ(I(v0),5.23N,5.24N)/0.01N)
.EXTRACT FILE=Power label = pow515 (1.2*integ(I(v0),5.24N,5.25N)/0.01N)
.EXTRACT FILE=Power label = pow516 (1.2*integ(I(v0),5.25N,5.26N)/0.01N)
.EXTRACT FILE=Power label = pow517 (1.2*integ(I(v0),5.26N,5.27N)/0.01N)
.EXTRACT FILE=Power label = pow518 (1.2*integ(I(v0),5.27N,5.28N)/0.01N)
.EXTRACT FILE=Power label = pow519 (1.2*integ(I(v0),5.28N,5.29N)/0.01N)
.EXTRACT FILE=Power label = pow520 (1.2*integ(I(v0),5.29N,5.3N)/0.01N)
.EXTRACT FILE=Power label = pow521 (1.2*integ(I(v0),5.3N,5.31N)/0.01N)
.EXTRACT FILE=Power label = pow522 (1.2*integ(I(v0),5.31N,5.32N)/0.01N)
.EXTRACT FILE=Power label = pow523 (1.2*integ(I(v0),5.32N,5.33N)/0.01N)
.EXTRACT FILE=Power label = pow524 (1.2*integ(I(v0),5.33N,5.34N)/0.01N)
.EXTRACT FILE=Power label = pow525 (1.2*integ(I(v0),5.34N,5.35N)/0.01N)
.EXTRACT FILE=Power label = pow526 (1.2*integ(I(v0),5.35N,5.36N)/0.01N)
.EXTRACT FILE=Power label = pow527 (1.2*integ(I(v0),5.36N,5.37N)/0.01N)
.EXTRACT FILE=Power label = pow528 (1.2*integ(I(v0),5.37N,5.38N)/0.01N)
.EXTRACT FILE=Power label = pow529 (1.2*integ(I(v0),5.38N,5.39N)/0.01N)
.EXTRACT FILE=Power label = pow530 (1.2*integ(I(v0),5.39N,5.4N)/0.01N)
.EXTRACT FILE=Power label = pow531 (1.2*integ(I(v0),5.4N,5.41N)/0.01N)
.EXTRACT FILE=Power label = pow532 (1.2*integ(I(v0),5.41N,5.42N)/0.01N)
.EXTRACT FILE=Power label = pow533 (1.2*integ(I(v0),5.42N,5.43N)/0.01N)
.EXTRACT FILE=Power label = pow534 (1.2*integ(I(v0),5.43N,5.44N)/0.01N)
.EXTRACT FILE=Power label = pow535 (1.2*integ(I(v0),5.44N,5.45N)/0.01N)
.EXTRACT FILE=Power label = pow536 (1.2*integ(I(v0),5.45N,5.46N)/0.01N)
.EXTRACT FILE=Power label = pow537 (1.2*integ(I(v0),5.46N,5.47N)/0.01N)
.EXTRACT FILE=Power label = pow538 (1.2*integ(I(v0),5.47N,5.48N)/0.01N)
.EXTRACT FILE=Power label = pow539 (1.2*integ(I(v0),5.48N,5.49N)/0.01N)
.EXTRACT FILE=Power label = pow540 (1.2*integ(I(v0),5.49N,5.5N)/0.01N)
.EXTRACT FILE=Power label = pow541 (1.2*integ(I(v0),5.5N,5.51N)/0.01N)
.EXTRACT FILE=Power label = pow542 (1.2*integ(I(v0),5.51N,5.52N)/0.01N)
.EXTRACT FILE=Power label = pow543 (1.2*integ(I(v0),5.52N,5.53N)/0.01N)
.EXTRACT FILE=Power label = pow544 (1.2*integ(I(v0),5.53N,5.54N)/0.01N)
.EXTRACT FILE=Power label = pow545 (1.2*integ(I(v0),5.54N,5.55N)/0.01N)
.EXTRACT FILE=Power label = pow546 (1.2*integ(I(v0),5.55N,5.56N)/0.01N)
.EXTRACT FILE=Power label = pow547 (1.2*integ(I(v0),5.56N,5.57N)/0.01N)
.EXTRACT FILE=Power label = pow548 (1.2*integ(I(v0),5.57N,5.58N)/0.01N)
.EXTRACT FILE=Power label = pow549 (1.2*integ(I(v0),5.58N,5.59N)/0.01N)
.EXTRACT FILE=Power label = pow550 (1.2*integ(I(v0),5.59N,5.6N)/0.01N)
.EXTRACT FILE=Power label = pow551 (1.2*integ(I(v0),5.6N,5.61N)/0.01N)
.EXTRACT FILE=Power label = pow552 (1.2*integ(I(v0),5.61N,5.62N)/0.01N)
.EXTRACT FILE=Power label = pow553 (1.2*integ(I(v0),5.62N,5.63N)/0.01N)
.EXTRACT FILE=Power label = pow554 (1.2*integ(I(v0),5.63N,5.64N)/0.01N)
.EXTRACT FILE=Power label = pow555 (1.2*integ(I(v0),5.64N,5.65N)/0.01N)
.EXTRACT FILE=Power label = pow556 (1.2*integ(I(v0),5.65N,5.66N)/0.01N)
.EXTRACT FILE=Power label = pow557 (1.2*integ(I(v0),5.66N,5.67N)/0.01N)
.EXTRACT FILE=Power label = pow558 (1.2*integ(I(v0),5.67N,5.68N)/0.01N)
.EXTRACT FILE=Power label = pow559 (1.2*integ(I(v0),5.68N,5.69N)/0.01N)
.EXTRACT FILE=Power label = pow560 (1.2*integ(I(v0),5.69N,5.7N)/0.01N)
.EXTRACT FILE=Power label = pow561 (1.2*integ(I(v0),5.7N,5.71N)/0.01N)
.EXTRACT FILE=Power label = pow562 (1.2*integ(I(v0),5.71N,5.72N)/0.01N)
.EXTRACT FILE=Power label = pow563 (1.2*integ(I(v0),5.72N,5.73N)/0.01N)
.EXTRACT FILE=Power label = pow564 (1.2*integ(I(v0),5.73N,5.74N)/0.01N)
.EXTRACT FILE=Power label = pow565 (1.2*integ(I(v0),5.74N,5.75N)/0.01N)
.EXTRACT FILE=Power label = pow566 (1.2*integ(I(v0),5.75N,5.76N)/0.01N)
.EXTRACT FILE=Power label = pow567 (1.2*integ(I(v0),5.76N,5.77N)/0.01N)
.EXTRACT FILE=Power label = pow568 (1.2*integ(I(v0),5.77N,5.78N)/0.01N)
.EXTRACT FILE=Power label = pow569 (1.2*integ(I(v0),5.78N,5.79N)/0.01N)
.EXTRACT FILE=Power label = pow570 (1.2*integ(I(v0),5.79N,5.8N)/0.01N)
.EXTRACT FILE=Power label = pow571 (1.2*integ(I(v0),5.8N,5.81N)/0.01N)
.EXTRACT FILE=Power label = pow572 (1.2*integ(I(v0),5.81N,5.82N)/0.01N)
.EXTRACT FILE=Power label = pow573 (1.2*integ(I(v0),5.82N,5.83N)/0.01N)
.EXTRACT FILE=Power label = pow574 (1.2*integ(I(v0),5.83N,5.84N)/0.01N)
.EXTRACT FILE=Power label = pow575 (1.2*integ(I(v0),5.84N,5.85N)/0.01N)
.EXTRACT FILE=Power label = pow576 (1.2*integ(I(v0),5.85N,5.86N)/0.01N)
.EXTRACT FILE=Power label = pow577 (1.2*integ(I(v0),5.86N,5.87N)/0.01N)
.EXTRACT FILE=Power label = pow578 (1.2*integ(I(v0),5.87N,5.88N)/0.01N)
.EXTRACT FILE=Power label = pow579 (1.2*integ(I(v0),5.88N,5.89N)/0.01N)
.EXTRACT FILE=Power label = pow580 (1.2*integ(I(v0),5.89N,5.9N)/0.01N)
.EXTRACT FILE=Power label = pow581 (1.2*integ(I(v0),5.9N,5.91N)/0.01N)
.EXTRACT FILE=Power label = pow582 (1.2*integ(I(v0),5.91N,5.92N)/0.01N)
.EXTRACT FILE=Power label = pow583 (1.2*integ(I(v0),5.92N,5.93N)/0.01N)
.EXTRACT FILE=Power label = pow584 (1.2*integ(I(v0),5.93N,5.94N)/0.01N)
.EXTRACT FILE=Power label = pow585 (1.2*integ(I(v0),5.94N,5.95N)/0.01N)
.EXTRACT FILE=Power label = pow586 (1.2*integ(I(v0),5.95N,5.96N)/0.01N)
.EXTRACT FILE=Power label = pow587 (1.2*integ(I(v0),5.96N,5.97N)/0.01N)
.EXTRACT FILE=Power label = pow588 (1.2*integ(I(v0),5.97N,5.98N)/0.01N)
.EXTRACT FILE=Power label = pow589 (1.2*integ(I(v0),5.98N,5.99N)/0.01N)
.EXTRACT FILE=Power label = pow590 (1.2*integ(I(v0),5.99N,6.0N)/0.01N)
.EXTRACT FILE=Power label = pow591 (1.2*integ(I(v0),6.0N,6.01N)/0.01N)
.EXTRACT FILE=Power label = pow592 (1.2*integ(I(v0),6.01N,6.02N)/0.01N)
.EXTRACT FILE=Power label = pow593 (1.2*integ(I(v0),6.02N,6.03N)/0.01N)
.EXTRACT FILE=Power label = pow594 (1.2*integ(I(v0),6.03N,6.04N)/0.01N)
.EXTRACT FILE=Power label = pow595 (1.2*integ(I(v0),6.04N,6.05N)/0.01N)
.EXTRACT FILE=Power label = pow596 (1.2*integ(I(v0),6.05N,6.06N)/0.01N)
.EXTRACT FILE=Power label = pow597 (1.2*integ(I(v0),6.06N,6.07N)/0.01N)
.EXTRACT FILE=Power label = pow598 (1.2*integ(I(v0),6.07N,6.08N)/0.01N)
.EXTRACT FILE=Power label = pow599 (1.2*integ(I(v0),6.08N,6.09N)/0.01N)
.EXTRACT FILE=Power label = pow600 (1.2*integ(I(v0),6.09N,6.1N)/0.01N)
.EXTRACT FILE=Power label = pow601 (1.2*integ(I(v0),6.1N,6.11N)/0.01N)
.EXTRACT FILE=Power label = pow602 (1.2*integ(I(v0),6.11N,6.12N)/0.01N)
.EXTRACT FILE=Power label = pow603 (1.2*integ(I(v0),6.12N,6.13N)/0.01N)
.EXTRACT FILE=Power label = pow604 (1.2*integ(I(v0),6.13N,6.14N)/0.01N)
.EXTRACT FILE=Power label = pow605 (1.2*integ(I(v0),6.14N,6.15N)/0.01N)
.EXTRACT FILE=Power label = pow606 (1.2*integ(I(v0),6.15N,6.16N)/0.01N)
.EXTRACT FILE=Power label = pow607 (1.2*integ(I(v0),6.16N,6.17N)/0.01N)
.EXTRACT FILE=Power label = pow608 (1.2*integ(I(v0),6.17N,6.18N)/0.01N)
.EXTRACT FILE=Power label = pow609 (1.2*integ(I(v0),6.18N,6.19N)/0.01N)
.EXTRACT FILE=Power label = pow610 (1.2*integ(I(v0),6.19N,6.2N)/0.01N)
.EXTRACT FILE=Power label = pow611 (1.2*integ(I(v0),6.2N,6.21N)/0.01N)
.EXTRACT FILE=Power label = pow612 (1.2*integ(I(v0),6.21N,6.22N)/0.01N)
.EXTRACT FILE=Power label = pow613 (1.2*integ(I(v0),6.22N,6.23N)/0.01N)
.EXTRACT FILE=Power label = pow614 (1.2*integ(I(v0),6.23N,6.24N)/0.01N)
.EXTRACT FILE=Power label = pow615 (1.2*integ(I(v0),6.24N,6.25N)/0.01N)
.EXTRACT FILE=Power label = pow616 (1.2*integ(I(v0),6.25N,6.26N)/0.01N)
.EXTRACT FILE=Power label = pow617 (1.2*integ(I(v0),6.26N,6.27N)/0.01N)
.EXTRACT FILE=Power label = pow618 (1.2*integ(I(v0),6.27N,6.28N)/0.01N)
.EXTRACT FILE=Power label = pow619 (1.2*integ(I(v0),6.28N,6.29N)/0.01N)
.EXTRACT FILE=Power label = pow620 (1.2*integ(I(v0),6.29N,6.3N)/0.01N)
.EXTRACT FILE=Power label = pow621 (1.2*integ(I(v0),6.3N,6.31N)/0.01N)
.EXTRACT FILE=Power label = pow622 (1.2*integ(I(v0),6.31N,6.32N)/0.01N)
.EXTRACT FILE=Power label = pow623 (1.2*integ(I(v0),6.32N,6.33N)/0.01N)
.EXTRACT FILE=Power label = pow624 (1.2*integ(I(v0),6.33N,6.34N)/0.01N)
.EXTRACT FILE=Power label = pow625 (1.2*integ(I(v0),6.34N,6.35N)/0.01N)
.EXTRACT FILE=Power label = pow626 (1.2*integ(I(v0),6.35N,6.36N)/0.01N)
.EXTRACT FILE=Power label = pow627 (1.2*integ(I(v0),6.36N,6.37N)/0.01N)
.EXTRACT FILE=Power label = pow628 (1.2*integ(I(v0),6.37N,6.38N)/0.01N)
.EXTRACT FILE=Power label = pow629 (1.2*integ(I(v0),6.38N,6.39N)/0.01N)
.EXTRACT FILE=Power label = pow630 (1.2*integ(I(v0),6.39N,6.4N)/0.01N)
.EXTRACT FILE=Power label = pow631 (1.2*integ(I(v0),6.4N,6.41N)/0.01N)
.EXTRACT FILE=Power label = pow632 (1.2*integ(I(v0),6.41N,6.42N)/0.01N)
.EXTRACT FILE=Power label = pow633 (1.2*integ(I(v0),6.42N,6.43N)/0.01N)
.EXTRACT FILE=Power label = pow634 (1.2*integ(I(v0),6.43N,6.44N)/0.01N)
.EXTRACT FILE=Power label = pow635 (1.2*integ(I(v0),6.44N,6.45N)/0.01N)
.EXTRACT FILE=Power label = pow636 (1.2*integ(I(v0),6.45N,6.46N)/0.01N)
.EXTRACT FILE=Power label = pow637 (1.2*integ(I(v0),6.46N,6.47N)/0.01N)
.EXTRACT FILE=Power label = pow638 (1.2*integ(I(v0),6.47N,6.48N)/0.01N)
.EXTRACT FILE=Power label = pow639 (1.2*integ(I(v0),6.48N,6.49N)/0.01N)
.EXTRACT FILE=Power label = pow640 (1.2*integ(I(v0),6.49N,6.5N)/0.01N)
.EXTRACT FILE=Power label = pow641 (1.2*integ(I(v0),6.5N,6.51N)/0.01N)
.EXTRACT FILE=Power label = pow642 (1.2*integ(I(v0),6.51N,6.52N)/0.01N)
.EXTRACT FILE=Power label = pow643 (1.2*integ(I(v0),6.52N,6.53N)/0.01N)
.EXTRACT FILE=Power label = pow644 (1.2*integ(I(v0),6.53N,6.54N)/0.01N)
.EXTRACT FILE=Power label = pow645 (1.2*integ(I(v0),6.54N,6.55N)/0.01N)
.EXTRACT FILE=Power label = pow646 (1.2*integ(I(v0),6.55N,6.56N)/0.01N)
.EXTRACT FILE=Power label = pow647 (1.2*integ(I(v0),6.56N,6.57N)/0.01N)
.EXTRACT FILE=Power label = pow648 (1.2*integ(I(v0),6.57N,6.58N)/0.01N)
.EXTRACT FILE=Power label = pow649 (1.2*integ(I(v0),6.58N,6.59N)/0.01N)
.EXTRACT FILE=Power label = pow650 (1.2*integ(I(v0),6.59N,6.6N)/0.01N)
.EXTRACT FILE=Power label = pow651 (1.2*integ(I(v0),6.6N,6.61N)/0.01N)
.EXTRACT FILE=Power label = pow652 (1.2*integ(I(v0),6.61N,6.62N)/0.01N)
.EXTRACT FILE=Power label = pow653 (1.2*integ(I(v0),6.62N,6.63N)/0.01N)
.EXTRACT FILE=Power label = pow654 (1.2*integ(I(v0),6.63N,6.64N)/0.01N)
.EXTRACT FILE=Power label = pow655 (1.2*integ(I(v0),6.64N,6.65N)/0.01N)
.EXTRACT FILE=Power label = pow656 (1.2*integ(I(v0),6.65N,6.66N)/0.01N)
.EXTRACT FILE=Power label = pow657 (1.2*integ(I(v0),6.66N,6.67N)/0.01N)
.EXTRACT FILE=Power label = pow658 (1.2*integ(I(v0),6.67N,6.68N)/0.01N)
.EXTRACT FILE=Power label = pow659 (1.2*integ(I(v0),6.68N,6.69N)/0.01N)
.EXTRACT FILE=Power label = pow660 (1.2*integ(I(v0),6.69N,6.7N)/0.01N)
.EXTRACT FILE=Power label = pow661 (1.2*integ(I(v0),6.7N,6.71N)/0.01N)
.EXTRACT FILE=Power label = pow662 (1.2*integ(I(v0),6.71N,6.72N)/0.01N)
.EXTRACT FILE=Power label = pow663 (1.2*integ(I(v0),6.72N,6.73N)/0.01N)
.EXTRACT FILE=Power label = pow664 (1.2*integ(I(v0),6.73N,6.74N)/0.01N)
.EXTRACT FILE=Power label = pow665 (1.2*integ(I(v0),6.74N,6.75N)/0.01N)
.EXTRACT FILE=Power label = pow666 (1.2*integ(I(v0),6.75N,6.76N)/0.01N)
.EXTRACT FILE=Power label = pow667 (1.2*integ(I(v0),6.76N,6.77N)/0.01N)
.EXTRACT FILE=Power label = pow668 (1.2*integ(I(v0),6.77N,6.78N)/0.01N)
.EXTRACT FILE=Power label = pow669 (1.2*integ(I(v0),6.78N,6.79N)/0.01N)
.EXTRACT FILE=Power label = pow670 (1.2*integ(I(v0),6.79N,6.8N)/0.01N)
.EXTRACT FILE=Power label = pow671 (1.2*integ(I(v0),6.8N,6.81N)/0.01N)
.EXTRACT FILE=Power label = pow672 (1.2*integ(I(v0),6.81N,6.82N)/0.01N)
.EXTRACT FILE=Power label = pow673 (1.2*integ(I(v0),6.82N,6.83N)/0.01N)
.EXTRACT FILE=Power label = pow674 (1.2*integ(I(v0),6.83N,6.84N)/0.01N)
.EXTRACT FILE=Power label = pow675 (1.2*integ(I(v0),6.84N,6.85N)/0.01N)
.EXTRACT FILE=Power label = pow676 (1.2*integ(I(v0),6.85N,6.86N)/0.01N)
.EXTRACT FILE=Power label = pow677 (1.2*integ(I(v0),6.86N,6.87N)/0.01N)
.EXTRACT FILE=Power label = pow678 (1.2*integ(I(v0),6.87N,6.88N)/0.01N)
.EXTRACT FILE=Power label = pow679 (1.2*integ(I(v0),6.88N,6.89N)/0.01N)
.EXTRACT FILE=Power label = pow680 (1.2*integ(I(v0),6.89N,6.9N)/0.01N)
.EXTRACT FILE=Power label = pow681 (1.2*integ(I(v0),6.9N,6.91N)/0.01N)
.EXTRACT FILE=Power label = pow682 (1.2*integ(I(v0),6.91N,6.92N)/0.01N)
.EXTRACT FILE=Power label = pow683 (1.2*integ(I(v0),6.92N,6.93N)/0.01N)
.EXTRACT FILE=Power label = pow684 (1.2*integ(I(v0),6.93N,6.94N)/0.01N)
.EXTRACT FILE=Power label = pow685 (1.2*integ(I(v0),6.94N,6.95N)/0.01N)
.EXTRACT FILE=Power label = pow686 (1.2*integ(I(v0),6.95N,6.96N)/0.01N)
.EXTRACT FILE=Power label = pow687 (1.2*integ(I(v0),6.96N,6.97N)/0.01N)
.EXTRACT FILE=Power label = pow688 (1.2*integ(I(v0),6.97N,6.98N)/0.01N)
.EXTRACT FILE=Power label = pow689 (1.2*integ(I(v0),6.98N,6.99N)/0.01N)
.EXTRACT FILE=Power label = pow690 (1.2*integ(I(v0),6.99N,7.0N)/0.01N)
.EXTRACT FILE=Power label = pow691 (1.2*integ(I(v0),7.0N,7.01N)/0.01N)
.EXTRACT FILE=Power label = pow692 (1.2*integ(I(v0),7.01N,7.02N)/0.01N)
.EXTRACT FILE=Power label = pow693 (1.2*integ(I(v0),7.02N,7.03N)/0.01N)
.EXTRACT FILE=Power label = pow694 (1.2*integ(I(v0),7.03N,7.04N)/0.01N)
.EXTRACT FILE=Power label = pow695 (1.2*integ(I(v0),7.04N,7.05N)/0.01N)
.EXTRACT FILE=Power label = pow696 (1.2*integ(I(v0),7.05N,7.06N)/0.01N)
.EXTRACT FILE=Power label = pow697 (1.2*integ(I(v0),7.06N,7.07N)/0.01N)
.EXTRACT FILE=Power label = pow698 (1.2*integ(I(v0),7.07N,7.08N)/0.01N)
.EXTRACT FILE=Power label = pow699 (1.2*integ(I(v0),7.08N,7.09N)/0.01N)
.EXTRACT FILE=Power label = pow700 (1.2*integ(I(v0),7.09N,7.1N)/0.01N)
.EXTRACT FILE=Power label = pow701 (1.2*integ(I(v0),7.1N,7.11N)/0.01N)
.EXTRACT FILE=Power label = pow702 (1.2*integ(I(v0),7.11N,7.12N)/0.01N)
.EXTRACT FILE=Power label = pow703 (1.2*integ(I(v0),7.12N,7.13N)/0.01N)
.EXTRACT FILE=Power label = pow704 (1.2*integ(I(v0),7.13N,7.14N)/0.01N)
.EXTRACT FILE=Power label = pow705 (1.2*integ(I(v0),7.14N,7.15N)/0.01N)
.EXTRACT FILE=Power label = pow706 (1.2*integ(I(v0),7.15N,7.16N)/0.01N)
.EXTRACT FILE=Power label = pow707 (1.2*integ(I(v0),7.16N,7.17N)/0.01N)
.EXTRACT FILE=Power label = pow708 (1.2*integ(I(v0),7.17N,7.18N)/0.01N)
.EXTRACT FILE=Power label = pow709 (1.2*integ(I(v0),7.18N,7.19N)/0.01N)
.EXTRACT FILE=Power label = pow710 (1.2*integ(I(v0),7.19N,7.2N)/0.01N)
.EXTRACT FILE=Power label = pow711 (1.2*integ(I(v0),7.2N,7.21N)/0.01N)
.EXTRACT FILE=Power label = pow712 (1.2*integ(I(v0),7.21N,7.22N)/0.01N)
.EXTRACT FILE=Power label = pow713 (1.2*integ(I(v0),7.22N,7.23N)/0.01N)
.EXTRACT FILE=Power label = pow714 (1.2*integ(I(v0),7.23N,7.24N)/0.01N)
.EXTRACT FILE=Power label = pow715 (1.2*integ(I(v0),7.24N,7.25N)/0.01N)
.EXTRACT FILE=Power label = pow716 (1.2*integ(I(v0),7.25N,7.26N)/0.01N)
.EXTRACT FILE=Power label = pow717 (1.2*integ(I(v0),7.26N,7.27N)/0.01N)
.EXTRACT FILE=Power label = pow718 (1.2*integ(I(v0),7.27N,7.28N)/0.01N)
.EXTRACT FILE=Power label = pow719 (1.2*integ(I(v0),7.28N,7.29N)/0.01N)
.EXTRACT FILE=Power label = pow720 (1.2*integ(I(v0),7.29N,7.3N)/0.01N)
.EXTRACT FILE=Power label = pow721 (1.2*integ(I(v0),7.3N,7.31N)/0.01N)
.EXTRACT FILE=Power label = pow722 (1.2*integ(I(v0),7.31N,7.32N)/0.01N)
.EXTRACT FILE=Power label = pow723 (1.2*integ(I(v0),7.32N,7.33N)/0.01N)
.EXTRACT FILE=Power label = pow724 (1.2*integ(I(v0),7.33N,7.34N)/0.01N)
.EXTRACT FILE=Power label = pow725 (1.2*integ(I(v0),7.34N,7.35N)/0.01N)
.EXTRACT FILE=Power label = pow726 (1.2*integ(I(v0),7.35N,7.36N)/0.01N)
.EXTRACT FILE=Power label = pow727 (1.2*integ(I(v0),7.36N,7.37N)/0.01N)
.EXTRACT FILE=Power label = pow728 (1.2*integ(I(v0),7.37N,7.38N)/0.01N)
.EXTRACT FILE=Power label = pow729 (1.2*integ(I(v0),7.38N,7.39N)/0.01N)
.EXTRACT FILE=Power label = pow730 (1.2*integ(I(v0),7.39N,7.4N)/0.01N)
.EXTRACT FILE=Power label = pow731 (1.2*integ(I(v0),7.4N,7.41N)/0.01N)
.EXTRACT FILE=Power label = pow732 (1.2*integ(I(v0),7.41N,7.42N)/0.01N)
.EXTRACT FILE=Power label = pow733 (1.2*integ(I(v0),7.42N,7.43N)/0.01N)
.EXTRACT FILE=Power label = pow734 (1.2*integ(I(v0),7.43N,7.44N)/0.01N)
.EXTRACT FILE=Power label = pow735 (1.2*integ(I(v0),7.44N,7.45N)/0.01N)
.EXTRACT FILE=Power label = pow736 (1.2*integ(I(v0),7.45N,7.46N)/0.01N)
.EXTRACT FILE=Power label = pow737 (1.2*integ(I(v0),7.46N,7.47N)/0.01N)
.EXTRACT FILE=Power label = pow738 (1.2*integ(I(v0),7.47N,7.48N)/0.01N)
.EXTRACT FILE=Power label = pow739 (1.2*integ(I(v0),7.48N,7.49N)/0.01N)
.EXTRACT FILE=Power label = pow740 (1.2*integ(I(v0),7.49N,7.5N)/0.01N)
.EXTRACT FILE=Power label = pow741 (1.2*integ(I(v0),7.5N,7.51N)/0.01N)
.EXTRACT FILE=Power label = pow742 (1.2*integ(I(v0),7.51N,7.52N)/0.01N)
.EXTRACT FILE=Power label = pow743 (1.2*integ(I(v0),7.52N,7.53N)/0.01N)
.EXTRACT FILE=Power label = pow744 (1.2*integ(I(v0),7.53N,7.54N)/0.01N)
.EXTRACT FILE=Power label = pow745 (1.2*integ(I(v0),7.54N,7.55N)/0.01N)
.EXTRACT FILE=Power label = pow746 (1.2*integ(I(v0),7.55N,7.56N)/0.01N)
.EXTRACT FILE=Power label = pow747 (1.2*integ(I(v0),7.56N,7.57N)/0.01N)
.EXTRACT FILE=Power label = pow748 (1.2*integ(I(v0),7.57N,7.58N)/0.01N)
.EXTRACT FILE=Power label = pow749 (1.2*integ(I(v0),7.58N,7.59N)/0.01N)
.EXTRACT FILE=Power label = pow750 (1.2*integ(I(v0),7.59N,7.6N)/0.01N)
.EXTRACT FILE=Power label = pow751 (1.2*integ(I(v0),7.6N,7.61N)/0.01N)
.EXTRACT FILE=Power label = pow752 (1.2*integ(I(v0),7.61N,7.62N)/0.01N)
.EXTRACT FILE=Power label = pow753 (1.2*integ(I(v0),7.62N,7.63N)/0.01N)
.EXTRACT FILE=Power label = pow754 (1.2*integ(I(v0),7.63N,7.64N)/0.01N)
.EXTRACT FILE=Power label = pow755 (1.2*integ(I(v0),7.64N,7.65N)/0.01N)
.EXTRACT FILE=Power label = pow756 (1.2*integ(I(v0),7.65N,7.66N)/0.01N)
.EXTRACT FILE=Power label = pow757 (1.2*integ(I(v0),7.66N,7.67N)/0.01N)
.EXTRACT FILE=Power label = pow758 (1.2*integ(I(v0),7.67N,7.68N)/0.01N)
.EXTRACT FILE=Power label = pow759 (1.2*integ(I(v0),7.68N,7.69N)/0.01N)
.EXTRACT FILE=Power label = pow760 (1.2*integ(I(v0),7.69N,7.7N)/0.01N)
.EXTRACT FILE=Power label = pow761 (1.2*integ(I(v0),7.7N,7.71N)/0.01N)
.EXTRACT FILE=Power label = pow762 (1.2*integ(I(v0),7.71N,7.72N)/0.01N)
.EXTRACT FILE=Power label = pow763 (1.2*integ(I(v0),7.72N,7.73N)/0.01N)
.EXTRACT FILE=Power label = pow764 (1.2*integ(I(v0),7.73N,7.74N)/0.01N)
.EXTRACT FILE=Power label = pow765 (1.2*integ(I(v0),7.74N,7.75N)/0.01N)
.EXTRACT FILE=Power label = pow766 (1.2*integ(I(v0),7.75N,7.76N)/0.01N)
.EXTRACT FILE=Power label = pow767 (1.2*integ(I(v0),7.76N,7.77N)/0.01N)
.EXTRACT FILE=Power label = pow768 (1.2*integ(I(v0),7.77N,7.78N)/0.01N)
.EXTRACT FILE=Power label = pow769 (1.2*integ(I(v0),7.78N,7.79N)/0.01N)
.EXTRACT FILE=Power label = pow770 (1.2*integ(I(v0),7.79N,7.8N)/0.01N)
.EXTRACT FILE=Power label = pow771 (1.2*integ(I(v0),7.8N,7.81N)/0.01N)
.EXTRACT FILE=Power label = pow772 (1.2*integ(I(v0),7.81N,7.82N)/0.01N)
.EXTRACT FILE=Power label = pow773 (1.2*integ(I(v0),7.82N,7.83N)/0.01N)
.EXTRACT FILE=Power label = pow774 (1.2*integ(I(v0),7.83N,7.84N)/0.01N)
.EXTRACT FILE=Power label = pow775 (1.2*integ(I(v0),7.84N,7.85N)/0.01N)
.EXTRACT FILE=Power label = pow776 (1.2*integ(I(v0),7.85N,7.86N)/0.01N)
.EXTRACT FILE=Power label = pow777 (1.2*integ(I(v0),7.86N,7.87N)/0.01N)
.EXTRACT FILE=Power label = pow778 (1.2*integ(I(v0),7.87N,7.88N)/0.01N)
.EXTRACT FILE=Power label = pow779 (1.2*integ(I(v0),7.88N,7.89N)/0.01N)
.EXTRACT FILE=Power label = pow780 (1.2*integ(I(v0),7.89N,7.9N)/0.01N)
.EXTRACT FILE=Power label = pow781 (1.2*integ(I(v0),7.9N,7.91N)/0.01N)
.EXTRACT FILE=Power label = pow782 (1.2*integ(I(v0),7.91N,7.92N)/0.01N)
.EXTRACT FILE=Power label = pow783 (1.2*integ(I(v0),7.92N,7.93N)/0.01N)
.EXTRACT FILE=Power label = pow784 (1.2*integ(I(v0),7.93N,7.94N)/0.01N)
.EXTRACT FILE=Power label = pow785 (1.2*integ(I(v0),7.94N,7.95N)/0.01N)
.EXTRACT FILE=Power label = pow786 (1.2*integ(I(v0),7.95N,7.96N)/0.01N)
.EXTRACT FILE=Power label = pow787 (1.2*integ(I(v0),7.96N,7.97N)/0.01N)
.EXTRACT FILE=Power label = pow788 (1.2*integ(I(v0),7.97N,7.98N)/0.01N)
.EXTRACT FILE=Power label = pow789 (1.2*integ(I(v0),7.98N,7.99N)/0.01N)
.EXTRACT FILE=Power label = pow790 (1.2*integ(I(v0),7.99N,8.0N)/0.01N)
.EXTRACT FILE=Power label = pow791 (1.2*integ(I(v0),8.0N,8.01N)/0.01N)
.EXTRACT FILE=Power label = pow792 (1.2*integ(I(v0),8.01N,8.02N)/0.01N)
.EXTRACT FILE=Power label = pow793 (1.2*integ(I(v0),8.02N,8.03N)/0.01N)
.EXTRACT FILE=Power label = pow794 (1.2*integ(I(v0),8.03N,8.04N)/0.01N)
.EXTRACT FILE=Power label = pow795 (1.2*integ(I(v0),8.04N,8.05N)/0.01N)
.EXTRACT FILE=Power label = pow796 (1.2*integ(I(v0),8.05N,8.06N)/0.01N)
.EXTRACT FILE=Power label = pow797 (1.2*integ(I(v0),8.06N,8.07N)/0.01N)
.EXTRACT FILE=Power label = pow798 (1.2*integ(I(v0),8.07N,8.08N)/0.01N)
.EXTRACT FILE=Power label = pow799 (1.2*integ(I(v0),8.08N,8.09N)/0.01N)
.EXTRACT FILE=Power label = pow800 (1.2*integ(I(v0),8.09N,8.1N)/0.01N)
.EXTRACT FILE=Power label = pow801 (1.2*integ(I(v0),8.1N,8.11N)/0.01N)
.EXTRACT FILE=Power label = pow802 (1.2*integ(I(v0),8.11N,8.12N)/0.01N)
.EXTRACT FILE=Power label = pow803 (1.2*integ(I(v0),8.12N,8.13N)/0.01N)
.EXTRACT FILE=Power label = pow804 (1.2*integ(I(v0),8.13N,8.14N)/0.01N)
.EXTRACT FILE=Power label = pow805 (1.2*integ(I(v0),8.14N,8.15N)/0.01N)
.EXTRACT FILE=Power label = pow806 (1.2*integ(I(v0),8.15N,8.16N)/0.01N)
.EXTRACT FILE=Power label = pow807 (1.2*integ(I(v0),8.16N,8.17N)/0.01N)
.EXTRACT FILE=Power label = pow808 (1.2*integ(I(v0),8.17N,8.18N)/0.01N)
.EXTRACT FILE=Power label = pow809 (1.2*integ(I(v0),8.18N,8.19N)/0.01N)
.EXTRACT FILE=Power label = pow810 (1.2*integ(I(v0),8.19N,8.2N)/0.01N)
.EXTRACT FILE=Power label = pow811 (1.2*integ(I(v0),8.2N,8.21N)/0.01N)
.EXTRACT FILE=Power label = pow812 (1.2*integ(I(v0),8.21N,8.22N)/0.01N)
.EXTRACT FILE=Power label = pow813 (1.2*integ(I(v0),8.22N,8.23N)/0.01N)
.EXTRACT FILE=Power label = pow814 (1.2*integ(I(v0),8.23N,8.24N)/0.01N)
.EXTRACT FILE=Power label = pow815 (1.2*integ(I(v0),8.24N,8.25N)/0.01N)
.EXTRACT FILE=Power label = pow816 (1.2*integ(I(v0),8.25N,8.26N)/0.01N)
.EXTRACT FILE=Power label = pow817 (1.2*integ(I(v0),8.26N,8.27N)/0.01N)
.EXTRACT FILE=Power label = pow818 (1.2*integ(I(v0),8.27N,8.28N)/0.01N)
.EXTRACT FILE=Power label = pow819 (1.2*integ(I(v0),8.28N,8.29N)/0.01N)
.EXTRACT FILE=Power label = pow820 (1.2*integ(I(v0),8.29N,8.3N)/0.01N)
.EXTRACT FILE=Power label = pow821 (1.2*integ(I(v0),8.3N,8.31N)/0.01N)
.EXTRACT FILE=Power label = pow822 (1.2*integ(I(v0),8.31N,8.32N)/0.01N)
.EXTRACT FILE=Power label = pow823 (1.2*integ(I(v0),8.32N,8.33N)/0.01N)
.EXTRACT FILE=Power label = pow824 (1.2*integ(I(v0),8.33N,8.34N)/0.01N)
.EXTRACT FILE=Power label = pow825 (1.2*integ(I(v0),8.34N,8.35N)/0.01N)
.EXTRACT FILE=Power label = pow826 (1.2*integ(I(v0),8.35N,8.36N)/0.01N)
.EXTRACT FILE=Power label = pow827 (1.2*integ(I(v0),8.36N,8.37N)/0.01N)
.EXTRACT FILE=Power label = pow828 (1.2*integ(I(v0),8.37N,8.38N)/0.01N)
.EXTRACT FILE=Power label = pow829 (1.2*integ(I(v0),8.38N,8.39N)/0.01N)
.EXTRACT FILE=Power label = pow830 (1.2*integ(I(v0),8.39N,8.4N)/0.01N)
.EXTRACT FILE=Power label = pow831 (1.2*integ(I(v0),8.4N,8.41N)/0.01N)
.EXTRACT FILE=Power label = pow832 (1.2*integ(I(v0),8.41N,8.42N)/0.01N)
.EXTRACT FILE=Power label = pow833 (1.2*integ(I(v0),8.42N,8.43N)/0.01N)
.EXTRACT FILE=Power label = pow834 (1.2*integ(I(v0),8.43N,8.44N)/0.01N)
.EXTRACT FILE=Power label = pow835 (1.2*integ(I(v0),8.44N,8.45N)/0.01N)
.EXTRACT FILE=Power label = pow836 (1.2*integ(I(v0),8.45N,8.46N)/0.01N)
.EXTRACT FILE=Power label = pow837 (1.2*integ(I(v0),8.46N,8.47N)/0.01N)
.EXTRACT FILE=Power label = pow838 (1.2*integ(I(v0),8.47N,8.48N)/0.01N)
.EXTRACT FILE=Power label = pow839 (1.2*integ(I(v0),8.48N,8.49N)/0.01N)
.EXTRACT FILE=Power label = pow840 (1.2*integ(I(v0),8.49N,8.5N)/0.01N)
.EXTRACT FILE=Power label = pow841 (1.2*integ(I(v0),8.5N,8.51N)/0.01N)
.EXTRACT FILE=Power label = pow842 (1.2*integ(I(v0),8.51N,8.52N)/0.01N)
.EXTRACT FILE=Power label = pow843 (1.2*integ(I(v0),8.52N,8.53N)/0.01N)
.EXTRACT FILE=Power label = pow844 (1.2*integ(I(v0),8.53N,8.54N)/0.01N)
.EXTRACT FILE=Power label = pow845 (1.2*integ(I(v0),8.54N,8.55N)/0.01N)
.EXTRACT FILE=Power label = pow846 (1.2*integ(I(v0),8.55N,8.56N)/0.01N)
.EXTRACT FILE=Power label = pow847 (1.2*integ(I(v0),8.56N,8.57N)/0.01N)
.EXTRACT FILE=Power label = pow848 (1.2*integ(I(v0),8.57N,8.58N)/0.01N)
.EXTRACT FILE=Power label = pow849 (1.2*integ(I(v0),8.58N,8.59N)/0.01N)
.EXTRACT FILE=Power label = pow850 (1.2*integ(I(v0),8.59N,8.6N)/0.01N)
.EXTRACT FILE=Power label = pow851 (1.2*integ(I(v0),8.6N,8.61N)/0.01N)
.EXTRACT FILE=Power label = pow852 (1.2*integ(I(v0),8.61N,8.62N)/0.01N)
.EXTRACT FILE=Power label = pow853 (1.2*integ(I(v0),8.62N,8.63N)/0.01N)
.EXTRACT FILE=Power label = pow854 (1.2*integ(I(v0),8.63N,8.64N)/0.01N)
.EXTRACT FILE=Power label = pow855 (1.2*integ(I(v0),8.64N,8.65N)/0.01N)
.EXTRACT FILE=Power label = pow856 (1.2*integ(I(v0),8.65N,8.66N)/0.01N)
.EXTRACT FILE=Power label = pow857 (1.2*integ(I(v0),8.66N,8.67N)/0.01N)
.EXTRACT FILE=Power label = pow858 (1.2*integ(I(v0),8.67N,8.68N)/0.01N)
.EXTRACT FILE=Power label = pow859 (1.2*integ(I(v0),8.68N,8.69N)/0.01N)
.EXTRACT FILE=Power label = pow860 (1.2*integ(I(v0),8.69N,8.7N)/0.01N)
.EXTRACT FILE=Power label = pow861 (1.2*integ(I(v0),8.7N,8.71N)/0.01N)
.EXTRACT FILE=Power label = pow862 (1.2*integ(I(v0),8.71N,8.72N)/0.01N)
.EXTRACT FILE=Power label = pow863 (1.2*integ(I(v0),8.72N,8.73N)/0.01N)
.EXTRACT FILE=Power label = pow864 (1.2*integ(I(v0),8.73N,8.74N)/0.01N)
.EXTRACT FILE=Power label = pow865 (1.2*integ(I(v0),8.74N,8.75N)/0.01N)
.EXTRACT FILE=Power label = pow866 (1.2*integ(I(v0),8.75N,8.76N)/0.01N)
.EXTRACT FILE=Power label = pow867 (1.2*integ(I(v0),8.76N,8.77N)/0.01N)
.EXTRACT FILE=Power label = pow868 (1.2*integ(I(v0),8.77N,8.78N)/0.01N)
.EXTRACT FILE=Power label = pow869 (1.2*integ(I(v0),8.78N,8.79N)/0.01N)
.EXTRACT FILE=Power label = pow870 (1.2*integ(I(v0),8.79N,8.8N)/0.01N)
.EXTRACT FILE=Power label = pow871 (1.2*integ(I(v0),8.8N,8.81N)/0.01N)
.EXTRACT FILE=Power label = pow872 (1.2*integ(I(v0),8.81N,8.82N)/0.01N)
.EXTRACT FILE=Power label = pow873 (1.2*integ(I(v0),8.82N,8.83N)/0.01N)
.EXTRACT FILE=Power label = pow874 (1.2*integ(I(v0),8.83N,8.84N)/0.01N)
.EXTRACT FILE=Power label = pow875 (1.2*integ(I(v0),8.84N,8.85N)/0.01N)
.EXTRACT FILE=Power label = pow876 (1.2*integ(I(v0),8.85N,8.86N)/0.01N)
.EXTRACT FILE=Power label = pow877 (1.2*integ(I(v0),8.86N,8.87N)/0.01N)
.EXTRACT FILE=Power label = pow878 (1.2*integ(I(v0),8.87N,8.88N)/0.01N)
.EXTRACT FILE=Power label = pow879 (1.2*integ(I(v0),8.88N,8.89N)/0.01N)
.EXTRACT FILE=Power label = pow880 (1.2*integ(I(v0),8.89N,8.9N)/0.01N)
.EXTRACT FILE=Power label = pow881 (1.2*integ(I(v0),8.9N,8.91N)/0.01N)
.EXTRACT FILE=Power label = pow882 (1.2*integ(I(v0),8.91N,8.92N)/0.01N)
.EXTRACT FILE=Power label = pow883 (1.2*integ(I(v0),8.92N,8.93N)/0.01N)
.EXTRACT FILE=Power label = pow884 (1.2*integ(I(v0),8.93N,8.94N)/0.01N)
.EXTRACT FILE=Power label = pow885 (1.2*integ(I(v0),8.94N,8.95N)/0.01N)
.EXTRACT FILE=Power label = pow886 (1.2*integ(I(v0),8.95N,8.96N)/0.01N)
.EXTRACT FILE=Power label = pow887 (1.2*integ(I(v0),8.96N,8.97N)/0.01N)
.EXTRACT FILE=Power label = pow888 (1.2*integ(I(v0),8.97N,8.98N)/0.01N)
.EXTRACT FILE=Power label = pow889 (1.2*integ(I(v0),8.98N,8.99N)/0.01N)
.EXTRACT FILE=Power label = pow890 (1.2*integ(I(v0),8.99N,9.0N)/0.01N)
.EXTRACT FILE=Power label = pow891 (1.2*integ(I(v0),9.0N,9.01N)/0.01N)
.EXTRACT FILE=Power label = pow892 (1.2*integ(I(v0),9.01N,9.02N)/0.01N)
.EXTRACT FILE=Power label = pow893 (1.2*integ(I(v0),9.02N,9.03N)/0.01N)
.EXTRACT FILE=Power label = pow894 (1.2*integ(I(v0),9.03N,9.04N)/0.01N)
.EXTRACT FILE=Power label = pow895 (1.2*integ(I(v0),9.04N,9.05N)/0.01N)
.EXTRACT FILE=Power label = pow896 (1.2*integ(I(v0),9.05N,9.06N)/0.01N)
.EXTRACT FILE=Power label = pow897 (1.2*integ(I(v0),9.06N,9.07N)/0.01N)
.EXTRACT FILE=Power label = pow898 (1.2*integ(I(v0),9.07N,9.08N)/0.01N)
.EXTRACT FILE=Power label = pow899 (1.2*integ(I(v0),9.08N,9.09N)/0.01N)
.EXTRACT FILE=Power label = pow900 (1.2*integ(I(v0),9.09N,9.1N)/0.01N)
.EXTRACT FILE=Power label = pow901 (1.2*integ(I(v0),9.1N,9.11N)/0.01N)
.EXTRACT FILE=Power label = pow902 (1.2*integ(I(v0),9.11N,9.12N)/0.01N)
.EXTRACT FILE=Power label = pow903 (1.2*integ(I(v0),9.12N,9.13N)/0.01N)
.EXTRACT FILE=Power label = pow904 (1.2*integ(I(v0),9.13N,9.14N)/0.01N)
.EXTRACT FILE=Power label = pow905 (1.2*integ(I(v0),9.14N,9.15N)/0.01N)
.EXTRACT FILE=Power label = pow906 (1.2*integ(I(v0),9.15N,9.16N)/0.01N)
.EXTRACT FILE=Power label = pow907 (1.2*integ(I(v0),9.16N,9.17N)/0.01N)
.EXTRACT FILE=Power label = pow908 (1.2*integ(I(v0),9.17N,9.18N)/0.01N)
.EXTRACT FILE=Power label = pow909 (1.2*integ(I(v0),9.18N,9.19N)/0.01N)
.EXTRACT FILE=Power label = pow910 (1.2*integ(I(v0),9.19N,9.2N)/0.01N)
.EXTRACT FILE=Power label = pow911 (1.2*integ(I(v0),9.2N,9.21N)/0.01N)
.EXTRACT FILE=Power label = pow912 (1.2*integ(I(v0),9.21N,9.22N)/0.01N)
.EXTRACT FILE=Power label = pow913 (1.2*integ(I(v0),9.22N,9.23N)/0.01N)
.EXTRACT FILE=Power label = pow914 (1.2*integ(I(v0),9.23N,9.24N)/0.01N)
.EXTRACT FILE=Power label = pow915 (1.2*integ(I(v0),9.24N,9.25N)/0.01N)
.EXTRACT FILE=Power label = pow916 (1.2*integ(I(v0),9.25N,9.26N)/0.01N)
.EXTRACT FILE=Power label = pow917 (1.2*integ(I(v0),9.26N,9.27N)/0.01N)
.EXTRACT FILE=Power label = pow918 (1.2*integ(I(v0),9.27N,9.28N)/0.01N)
.EXTRACT FILE=Power label = pow919 (1.2*integ(I(v0),9.28N,9.29N)/0.01N)
.EXTRACT FILE=Power label = pow920 (1.2*integ(I(v0),9.29N,9.3N)/0.01N)
.EXTRACT FILE=Power label = pow921 (1.2*integ(I(v0),9.3N,9.31N)/0.01N)
.EXTRACT FILE=Power label = pow922 (1.2*integ(I(v0),9.31N,9.32N)/0.01N)
.EXTRACT FILE=Power label = pow923 (1.2*integ(I(v0),9.32N,9.33N)/0.01N)
.EXTRACT FILE=Power label = pow924 (1.2*integ(I(v0),9.33N,9.34N)/0.01N)
.EXTRACT FILE=Power label = pow925 (1.2*integ(I(v0),9.34N,9.35N)/0.01N)
.EXTRACT FILE=Power label = pow926 (1.2*integ(I(v0),9.35N,9.36N)/0.01N)
.EXTRACT FILE=Power label = pow927 (1.2*integ(I(v0),9.36N,9.37N)/0.01N)
.EXTRACT FILE=Power label = pow928 (1.2*integ(I(v0),9.37N,9.38N)/0.01N)
.EXTRACT FILE=Power label = pow929 (1.2*integ(I(v0),9.38N,9.39N)/0.01N)
.EXTRACT FILE=Power label = pow930 (1.2*integ(I(v0),9.39N,9.4N)/0.01N)
.EXTRACT FILE=Power label = pow931 (1.2*integ(I(v0),9.4N,9.41N)/0.01N)
.EXTRACT FILE=Power label = pow932 (1.2*integ(I(v0),9.41N,9.42N)/0.01N)
.EXTRACT FILE=Power label = pow933 (1.2*integ(I(v0),9.42N,9.43N)/0.01N)
.EXTRACT FILE=Power label = pow934 (1.2*integ(I(v0),9.43N,9.44N)/0.01N)
.EXTRACT FILE=Power label = pow935 (1.2*integ(I(v0),9.44N,9.45N)/0.01N)
.EXTRACT FILE=Power label = pow936 (1.2*integ(I(v0),9.45N,9.46N)/0.01N)
.EXTRACT FILE=Power label = pow937 (1.2*integ(I(v0),9.46N,9.47N)/0.01N)
.EXTRACT FILE=Power label = pow938 (1.2*integ(I(v0),9.47N,9.48N)/0.01N)
.EXTRACT FILE=Power label = pow939 (1.2*integ(I(v0),9.48N,9.49N)/0.01N)
.EXTRACT FILE=Power label = pow940 (1.2*integ(I(v0),9.49N,9.5N)/0.01N)
.EXTRACT FILE=Power label = pow941 (1.2*integ(I(v0),9.5N,9.51N)/0.01N)
.EXTRACT FILE=Power label = pow942 (1.2*integ(I(v0),9.51N,9.52N)/0.01N)
.EXTRACT FILE=Power label = pow943 (1.2*integ(I(v0),9.52N,9.53N)/0.01N)
.EXTRACT FILE=Power label = pow944 (1.2*integ(I(v0),9.53N,9.54N)/0.01N)
.EXTRACT FILE=Power label = pow945 (1.2*integ(I(v0),9.54N,9.55N)/0.01N)
.EXTRACT FILE=Power label = pow946 (1.2*integ(I(v0),9.55N,9.56N)/0.01N)
.EXTRACT FILE=Power label = pow947 (1.2*integ(I(v0),9.56N,9.57N)/0.01N)
.EXTRACT FILE=Power label = pow948 (1.2*integ(I(v0),9.57N,9.58N)/0.01N)
.EXTRACT FILE=Power label = pow949 (1.2*integ(I(v0),9.58N,9.59N)/0.01N)
.EXTRACT FILE=Power label = pow950 (1.2*integ(I(v0),9.59N,9.6N)/0.01N)
.EXTRACT FILE=Power label = pow951 (1.2*integ(I(v0),9.6N,9.61N)/0.01N)
.EXTRACT FILE=Power label = pow952 (1.2*integ(I(v0),9.61N,9.62N)/0.01N)
.EXTRACT FILE=Power label = pow953 (1.2*integ(I(v0),9.62N,9.63N)/0.01N)
.EXTRACT FILE=Power label = pow954 (1.2*integ(I(v0),9.63N,9.64N)/0.01N)
.EXTRACT FILE=Power label = pow955 (1.2*integ(I(v0),9.64N,9.65N)/0.01N)
.EXTRACT FILE=Power label = pow956 (1.2*integ(I(v0),9.65N,9.66N)/0.01N)
.EXTRACT FILE=Power label = pow957 (1.2*integ(I(v0),9.66N,9.67N)/0.01N)
.EXTRACT FILE=Power label = pow958 (1.2*integ(I(v0),9.67N,9.68N)/0.01N)
.EXTRACT FILE=Power label = pow959 (1.2*integ(I(v0),9.68N,9.69N)/0.01N)
.EXTRACT FILE=Power label = pow960 (1.2*integ(I(v0),9.69N,9.7N)/0.01N)
.EXTRACT FILE=Power label = pow961 (1.2*integ(I(v0),9.7N,9.71N)/0.01N)
.EXTRACT FILE=Power label = pow962 (1.2*integ(I(v0),9.71N,9.72N)/0.01N)
.EXTRACT FILE=Power label = pow963 (1.2*integ(I(v0),9.72N,9.73N)/0.01N)
.EXTRACT FILE=Power label = pow964 (1.2*integ(I(v0),9.73N,9.74N)/0.01N)
.EXTRACT FILE=Power label = pow965 (1.2*integ(I(v0),9.74N,9.75N)/0.01N)
.EXTRACT FILE=Power label = pow966 (1.2*integ(I(v0),9.75N,9.76N)/0.01N)
.EXTRACT FILE=Power label = pow967 (1.2*integ(I(v0),9.76N,9.77N)/0.01N)
.EXTRACT FILE=Power label = pow968 (1.2*integ(I(v0),9.77N,9.78N)/0.01N)
.EXTRACT FILE=Power label = pow969 (1.2*integ(I(v0),9.78N,9.79N)/0.01N)
.EXTRACT FILE=Power label = pow970 (1.2*integ(I(v0),9.79N,9.8N)/0.01N)
.EXTRACT FILE=Power label = pow971 (1.2*integ(I(v0),9.8N,9.81N)/0.01N)
.EXTRACT FILE=Power label = pow972 (1.2*integ(I(v0),9.81N,9.82N)/0.01N)
.EXTRACT FILE=Power label = pow973 (1.2*integ(I(v0),9.82N,9.83N)/0.01N)
.EXTRACT FILE=Power label = pow974 (1.2*integ(I(v0),9.83N,9.84N)/0.01N)
.EXTRACT FILE=Power label = pow975 (1.2*integ(I(v0),9.84N,9.85N)/0.01N)
.EXTRACT FILE=Power label = pow976 (1.2*integ(I(v0),9.85N,9.86N)/0.01N)
.EXTRACT FILE=Power label = pow977 (1.2*integ(I(v0),9.86N,9.87N)/0.01N)
.EXTRACT FILE=Power label = pow978 (1.2*integ(I(v0),9.87N,9.88N)/0.01N)
.EXTRACT FILE=Power label = pow979 (1.2*integ(I(v0),9.88N,9.89N)/0.01N)
.EXTRACT FILE=Power label = pow980 (1.2*integ(I(v0),9.89N,9.9N)/0.01N)
.EXTRACT FILE=Power label = pow981 (1.2*integ(I(v0),9.9N,9.91N)/0.01N)
.EXTRACT FILE=Power label = pow982 (1.2*integ(I(v0),9.91N,9.92N)/0.01N)
.EXTRACT FILE=Power label = pow983 (1.2*integ(I(v0),9.92N,9.93N)/0.01N)
.EXTRACT FILE=Power label = pow984 (1.2*integ(I(v0),9.93N,9.94N)/0.01N)
.EXTRACT FILE=Power label = pow985 (1.2*integ(I(v0),9.94N,9.95N)/0.01N)
.EXTRACT FILE=Power label = pow986 (1.2*integ(I(v0),9.95N,9.96N)/0.01N)
.EXTRACT FILE=Power label = pow987 (1.2*integ(I(v0),9.96N,9.97N)/0.01N)
.EXTRACT FILE=Power label = pow988 (1.2*integ(I(v0),9.97N,9.98N)/0.01N)
.EXTRACT FILE=Power label = pow989 (1.2*integ(I(v0),9.98N,9.99N)/0.01N)
.EXTRACT FILE=Power label = pow990 (1.2*integ(I(v0),9.99N,10.0N)/0.01N)
.EXTRACT FILE=Power label = pow991 (1.2*integ(I(v0),10.0N,10.01N)/0.01N)
.EXTRACT FILE=Power label = pow992 (1.2*integ(I(v0),10.01N,10.02N)/0.01N)
.EXTRACT FILE=Power label = pow993 (1.2*integ(I(v0),10.02N,10.03N)/0.01N)
.EXTRACT FILE=Power label = pow994 (1.2*integ(I(v0),10.03N,10.04N)/0.01N)
.EXTRACT FILE=Power label = pow995 (1.2*integ(I(v0),10.04N,10.05N)/0.01N)
.EXTRACT FILE=Power label = pow996 (1.2*integ(I(v0),10.05N,10.06N)/0.01N)
.EXTRACT FILE=Power label = pow997 (1.2*integ(I(v0),10.06N,10.07N)/0.01N)
.EXTRACT FILE=Power label = pow998 (1.2*integ(I(v0),10.07N,10.08N)/0.01N)
.EXTRACT FILE=Power label = pow999 (1.2*integ(I(v0),10.08N,10.09N)/0.01N)
.EXTRACT FILE=Power label = pow1000 (1.2*integ(I(v0),10.09N,10.1N)/0.01N)
.EXTRACT FILE=Power label = pow1001 (1.2*integ(I(v0),10.1N,10.11N)/0.01N)
.EXTRACT FILE=Power label = pow1002 (1.2*integ(I(v0),10.11N,10.12N)/0.01N)
.EXTRACT FILE=Power label = pow1003 (1.2*integ(I(v0),10.12N,10.13N)/0.01N)
.EXTRACT FILE=Power label = pow1004 (1.2*integ(I(v0),10.13N,10.14N)/0.01N)
.EXTRACT FILE=Power label = pow1005 (1.2*integ(I(v0),10.14N,10.15N)/0.01N)
.EXTRACT FILE=Power label = pow1006 (1.2*integ(I(v0),10.15N,10.16N)/0.01N)
.EXTRACT FILE=Power label = pow1007 (1.2*integ(I(v0),10.16N,10.17N)/0.01N)
.EXTRACT FILE=Power label = pow1008 (1.2*integ(I(v0),10.17N,10.18N)/0.01N)
.EXTRACT FILE=Power label = pow1009 (1.2*integ(I(v0),10.18N,10.19N)/0.01N)
.EXTRACT FILE=Power label = pow1010 (1.2*integ(I(v0),10.19N,10.2N)/0.01N)
.EXTRACT FILE=Power label = pow1011 (1.2*integ(I(v0),10.2N,10.21N)/0.01N)
.EXTRACT FILE=Power label = pow1012 (1.2*integ(I(v0),10.21N,10.22N)/0.01N)
.EXTRACT FILE=Power label = pow1013 (1.2*integ(I(v0),10.22N,10.23N)/0.01N)
.EXTRACT FILE=Power label = pow1014 (1.2*integ(I(v0),10.23N,10.24N)/0.01N)
.EXTRACT FILE=Power label = pow1015 (1.2*integ(I(v0),10.24N,10.25N)/0.01N)
.EXTRACT FILE=Power label = pow1016 (1.2*integ(I(v0),10.25N,10.26N)/0.01N)
.EXTRACT FILE=Power label = pow1017 (1.2*integ(I(v0),10.26N,10.27N)/0.01N)
.EXTRACT FILE=Power label = pow1018 (1.2*integ(I(v0),10.27N,10.28N)/0.01N)
.EXTRACT FILE=Power label = pow1019 (1.2*integ(I(v0),10.28N,10.29N)/0.01N)
.EXTRACT FILE=Power label = pow1020 (1.2*integ(I(v0),10.29N,10.3N)/0.01N)
.EXTRACT FILE=Power label = pow1021 (1.2*integ(I(v0),10.3N,10.31N)/0.01N)
.EXTRACT FILE=Power label = pow1022 (1.2*integ(I(v0),10.31N,10.32N)/0.01N)
.EXTRACT FILE=Power label = pow1023 (1.2*integ(I(v0),10.32N,10.33N)/0.01N)
.EXTRACT FILE=Power label = pow1024 (1.2*integ(I(v0),10.33N,10.34N)/0.01N)
.EXTRACT FILE=Power label = pow1025 (1.2*integ(I(v0),10.34N,10.35N)/0.01N)
.EXTRACT FILE=Power label = pow1026 (1.2*integ(I(v0),10.35N,10.36N)/0.01N)
.EXTRACT FILE=Power label = pow1027 (1.2*integ(I(v0),10.36N,10.37N)/0.01N)
.EXTRACT FILE=Power label = pow1028 (1.2*integ(I(v0),10.37N,10.38N)/0.01N)
.EXTRACT FILE=Power label = pow1029 (1.2*integ(I(v0),10.38N,10.39N)/0.01N)
.EXTRACT FILE=Power label = pow1030 (1.2*integ(I(v0),10.39N,10.4N)/0.01N)
.EXTRACT FILE=Power label = pow1031 (1.2*integ(I(v0),10.4N,10.41N)/0.01N)
.EXTRACT FILE=Power label = pow1032 (1.2*integ(I(v0),10.41N,10.42N)/0.01N)
.EXTRACT FILE=Power label = pow1033 (1.2*integ(I(v0),10.42N,10.43N)/0.01N)
.EXTRACT FILE=Power label = pow1034 (1.2*integ(I(v0),10.43N,10.44N)/0.01N)
.EXTRACT FILE=Power label = pow1035 (1.2*integ(I(v0),10.44N,10.45N)/0.01N)
.EXTRACT FILE=Power label = pow1036 (1.2*integ(I(v0),10.45N,10.46N)/0.01N)
.EXTRACT FILE=Power label = pow1037 (1.2*integ(I(v0),10.46N,10.47N)/0.01N)
.EXTRACT FILE=Power label = pow1038 (1.2*integ(I(v0),10.47N,10.48N)/0.01N)
.EXTRACT FILE=Power label = pow1039 (1.2*integ(I(v0),10.48N,10.49N)/0.01N)
.EXTRACT FILE=Power label = pow1040 (1.2*integ(I(v0),10.49N,10.5N)/0.01N)
.EXTRACT FILE=Power label = pow1041 (1.2*integ(I(v0),10.5N,10.51N)/0.01N)
.EXTRACT FILE=Power label = pow1042 (1.2*integ(I(v0),10.51N,10.52N)/0.01N)
.EXTRACT FILE=Power label = pow1043 (1.2*integ(I(v0),10.52N,10.53N)/0.01N)
.EXTRACT FILE=Power label = pow1044 (1.2*integ(I(v0),10.53N,10.54N)/0.01N)
.EXTRACT FILE=Power label = pow1045 (1.2*integ(I(v0),10.54N,10.55N)/0.01N)
.EXTRACT FILE=Power label = pow1046 (1.2*integ(I(v0),10.55N,10.56N)/0.01N)
.EXTRACT FILE=Power label = pow1047 (1.2*integ(I(v0),10.56N,10.57N)/0.01N)
.EXTRACT FILE=Power label = pow1048 (1.2*integ(I(v0),10.57N,10.58N)/0.01N)
.EXTRACT FILE=Power label = pow1049 (1.2*integ(I(v0),10.58N,10.59N)/0.01N)
.EXTRACT FILE=Power label = pow1050 (1.2*integ(I(v0),10.59N,10.6N)/0.01N)
.EXTRACT FILE=Power label = pow1051 (1.2*integ(I(v0),10.6N,10.61N)/0.01N)
.EXTRACT FILE=Power label = pow1052 (1.2*integ(I(v0),10.61N,10.62N)/0.01N)
.EXTRACT FILE=Power label = pow1053 (1.2*integ(I(v0),10.62N,10.63N)/0.01N)
.EXTRACT FILE=Power label = pow1054 (1.2*integ(I(v0),10.63N,10.64N)/0.01N)
.EXTRACT FILE=Power label = pow1055 (1.2*integ(I(v0),10.64N,10.65N)/0.01N)
.EXTRACT FILE=Power label = pow1056 (1.2*integ(I(v0),10.65N,10.66N)/0.01N)
.EXTRACT FILE=Power label = pow1057 (1.2*integ(I(v0),10.66N,10.67N)/0.01N)
.EXTRACT FILE=Power label = pow1058 (1.2*integ(I(v0),10.67N,10.68N)/0.01N)
.EXTRACT FILE=Power label = pow1059 (1.2*integ(I(v0),10.68N,10.69N)/0.01N)
.EXTRACT FILE=Power label = pow1060 (1.2*integ(I(v0),10.69N,10.7N)/0.01N)
.EXTRACT FILE=Power label = pow1061 (1.2*integ(I(v0),10.7N,10.71N)/0.01N)
.EXTRACT FILE=Power label = pow1062 (1.2*integ(I(v0),10.71N,10.72N)/0.01N)
.EXTRACT FILE=Power label = pow1063 (1.2*integ(I(v0),10.72N,10.73N)/0.01N)
.EXTRACT FILE=Power label = pow1064 (1.2*integ(I(v0),10.73N,10.74N)/0.01N)
.EXTRACT FILE=Power label = pow1065 (1.2*integ(I(v0),10.74N,10.75N)/0.01N)
.EXTRACT FILE=Power label = pow1066 (1.2*integ(I(v0),10.75N,10.76N)/0.01N)
.EXTRACT FILE=Power label = pow1067 (1.2*integ(I(v0),10.76N,10.77N)/0.01N)
.EXTRACT FILE=Power label = pow1068 (1.2*integ(I(v0),10.77N,10.78N)/0.01N)
.EXTRACT FILE=Power label = pow1069 (1.2*integ(I(v0),10.78N,10.79N)/0.01N)
.EXTRACT FILE=Power label = pow1070 (1.2*integ(I(v0),10.79N,10.8N)/0.01N)
.EXTRACT FILE=Power label = pow1071 (1.2*integ(I(v0),10.8N,10.81N)/0.01N)
.EXTRACT FILE=Power label = pow1072 (1.2*integ(I(v0),10.81N,10.82N)/0.01N)
.EXTRACT FILE=Power label = pow1073 (1.2*integ(I(v0),10.82N,10.83N)/0.01N)
.EXTRACT FILE=Power label = pow1074 (1.2*integ(I(v0),10.83N,10.84N)/0.01N)
.EXTRACT FILE=Power label = pow1075 (1.2*integ(I(v0),10.84N,10.85N)/0.01N)
.EXTRACT FILE=Power label = pow1076 (1.2*integ(I(v0),10.85N,10.86N)/0.01N)
.EXTRACT FILE=Power label = pow1077 (1.2*integ(I(v0),10.86N,10.87N)/0.01N)
.EXTRACT FILE=Power label = pow1078 (1.2*integ(I(v0),10.87N,10.88N)/0.01N)
.EXTRACT FILE=Power label = pow1079 (1.2*integ(I(v0),10.88N,10.89N)/0.01N)
.EXTRACT FILE=Power label = pow1080 (1.2*integ(I(v0),10.89N,10.9N)/0.01N)
.EXTRACT FILE=Power label = pow1081 (1.2*integ(I(v0),10.9N,10.91N)/0.01N)
.EXTRACT FILE=Power label = pow1082 (1.2*integ(I(v0),10.91N,10.92N)/0.01N)
.EXTRACT FILE=Power label = pow1083 (1.2*integ(I(v0),10.92N,10.93N)/0.01N)
.EXTRACT FILE=Power label = pow1084 (1.2*integ(I(v0),10.93N,10.94N)/0.01N)
.EXTRACT FILE=Power label = pow1085 (1.2*integ(I(v0),10.94N,10.95N)/0.01N)
.EXTRACT FILE=Power label = pow1086 (1.2*integ(I(v0),10.95N,10.96N)/0.01N)
.EXTRACT FILE=Power label = pow1087 (1.2*integ(I(v0),10.96N,10.97N)/0.01N)
.EXTRACT FILE=Power label = pow1088 (1.2*integ(I(v0),10.97N,10.98N)/0.01N)
.EXTRACT FILE=Power label = pow1089 (1.2*integ(I(v0),10.98N,10.99N)/0.01N)
.EXTRACT FILE=Power label = pow1090 (1.2*integ(I(v0),10.99N,11.0N)/0.01N)
.EXTRACT FILE=Power label = pow1091 (1.2*integ(I(v0),11.0N,11.01N)/0.01N)
.EXTRACT FILE=Power label = pow1092 (1.2*integ(I(v0),11.01N,11.02N)/0.01N)
.EXTRACT FILE=Power label = pow1093 (1.2*integ(I(v0),11.02N,11.03N)/0.01N)
.EXTRACT FILE=Power label = pow1094 (1.2*integ(I(v0),11.03N,11.04N)/0.01N)
.EXTRACT FILE=Power label = pow1095 (1.2*integ(I(v0),11.04N,11.05N)/0.01N)
.EXTRACT FILE=Power label = pow1096 (1.2*integ(I(v0),11.05N,11.06N)/0.01N)
.EXTRACT FILE=Power label = pow1097 (1.2*integ(I(v0),11.06N,11.07N)/0.01N)
.EXTRACT FILE=Power label = pow1098 (1.2*integ(I(v0),11.07N,11.08N)/0.01N)
.EXTRACT FILE=Power label = pow1099 (1.2*integ(I(v0),11.08N,11.09N)/0.01N)
.EXTRACT FILE=Power label = pow1100 (1.2*integ(I(v0),11.09N,11.1N)/0.01N)
.EXTRACT FILE=Power label = pow1101 (1.2*integ(I(v0),11.1N,11.11N)/0.01N)
.EXTRACT FILE=Power label = pow1102 (1.2*integ(I(v0),11.11N,11.12N)/0.01N)
.EXTRACT FILE=Power label = pow1103 (1.2*integ(I(v0),11.12N,11.13N)/0.01N)
.EXTRACT FILE=Power label = pow1104 (1.2*integ(I(v0),11.13N,11.14N)/0.01N)
.EXTRACT FILE=Power label = pow1105 (1.2*integ(I(v0),11.14N,11.15N)/0.01N)
.EXTRACT FILE=Power label = pow1106 (1.2*integ(I(v0),11.15N,11.16N)/0.01N)
.EXTRACT FILE=Power label = pow1107 (1.2*integ(I(v0),11.16N,11.17N)/0.01N)
.EXTRACT FILE=Power label = pow1108 (1.2*integ(I(v0),11.17N,11.18N)/0.01N)
.EXTRACT FILE=Power label = pow1109 (1.2*integ(I(v0),11.18N,11.19N)/0.01N)
.EXTRACT FILE=Power label = pow1110 (1.2*integ(I(v0),11.19N,11.2N)/0.01N)
.EXTRACT FILE=Power label = pow1111 (1.2*integ(I(v0),11.2N,11.21N)/0.01N)
.EXTRACT FILE=Power label = pow1112 (1.2*integ(I(v0),11.21N,11.22N)/0.01N)
.EXTRACT FILE=Power label = pow1113 (1.2*integ(I(v0),11.22N,11.23N)/0.01N)
.EXTRACT FILE=Power label = pow1114 (1.2*integ(I(v0),11.23N,11.24N)/0.01N)
.EXTRACT FILE=Power label = pow1115 (1.2*integ(I(v0),11.24N,11.25N)/0.01N)
.EXTRACT FILE=Power label = pow1116 (1.2*integ(I(v0),11.25N,11.26N)/0.01N)
.EXTRACT FILE=Power label = pow1117 (1.2*integ(I(v0),11.26N,11.27N)/0.01N)
.EXTRACT FILE=Power label = pow1118 (1.2*integ(I(v0),11.27N,11.28N)/0.01N)
.EXTRACT FILE=Power label = pow1119 (1.2*integ(I(v0),11.28N,11.29N)/0.01N)
.EXTRACT FILE=Power label = pow1120 (1.2*integ(I(v0),11.29N,11.3N)/0.01N)
.EXTRACT FILE=Power label = pow1121 (1.2*integ(I(v0),11.3N,11.31N)/0.01N)
.EXTRACT FILE=Power label = pow1122 (1.2*integ(I(v0),11.31N,11.32N)/0.01N)
.EXTRACT FILE=Power label = pow1123 (1.2*integ(I(v0),11.32N,11.33N)/0.01N)
.EXTRACT FILE=Power label = pow1124 (1.2*integ(I(v0),11.33N,11.34N)/0.01N)
.EXTRACT FILE=Power label = pow1125 (1.2*integ(I(v0),11.34N,11.35N)/0.01N)
.EXTRACT FILE=Power label = pow1126 (1.2*integ(I(v0),11.35N,11.36N)/0.01N)
.EXTRACT FILE=Power label = pow1127 (1.2*integ(I(v0),11.36N,11.37N)/0.01N)
.EXTRACT FILE=Power label = pow1128 (1.2*integ(I(v0),11.37N,11.38N)/0.01N)
.EXTRACT FILE=Power label = pow1129 (1.2*integ(I(v0),11.38N,11.39N)/0.01N)
.EXTRACT FILE=Power label = pow1130 (1.2*integ(I(v0),11.39N,11.4N)/0.01N)
.EXTRACT FILE=Power label = pow1131 (1.2*integ(I(v0),11.4N,11.41N)/0.01N)
.EXTRACT FILE=Power label = pow1132 (1.2*integ(I(v0),11.41N,11.42N)/0.01N)
.EXTRACT FILE=Power label = pow1133 (1.2*integ(I(v0),11.42N,11.43N)/0.01N)
.EXTRACT FILE=Power label = pow1134 (1.2*integ(I(v0),11.43N,11.44N)/0.01N)
.EXTRACT FILE=Power label = pow1135 (1.2*integ(I(v0),11.44N,11.45N)/0.01N)
.EXTRACT FILE=Power label = pow1136 (1.2*integ(I(v0),11.45N,11.46N)/0.01N)
.EXTRACT FILE=Power label = pow1137 (1.2*integ(I(v0),11.46N,11.47N)/0.01N)
.EXTRACT FILE=Power label = pow1138 (1.2*integ(I(v0),11.47N,11.48N)/0.01N)
.EXTRACT FILE=Power label = pow1139 (1.2*integ(I(v0),11.48N,11.49N)/0.01N)
.EXTRACT FILE=Power label = pow1140 (1.2*integ(I(v0),11.49N,11.5N)/0.01N)
.EXTRACT FILE=Power label = pow1141 (1.2*integ(I(v0),11.5N,11.51N)/0.01N)
.EXTRACT FILE=Power label = pow1142 (1.2*integ(I(v0),11.51N,11.52N)/0.01N)
.EXTRACT FILE=Power label = pow1143 (1.2*integ(I(v0),11.52N,11.53N)/0.01N)
.EXTRACT FILE=Power label = pow1144 (1.2*integ(I(v0),11.53N,11.54N)/0.01N)
.EXTRACT FILE=Power label = pow1145 (1.2*integ(I(v0),11.54N,11.55N)/0.01N)
.EXTRACT FILE=Power label = pow1146 (1.2*integ(I(v0),11.55N,11.56N)/0.01N)
.EXTRACT FILE=Power label = pow1147 (1.2*integ(I(v0),11.56N,11.57N)/0.01N)
.EXTRACT FILE=Power label = pow1148 (1.2*integ(I(v0),11.57N,11.58N)/0.01N)
.EXTRACT FILE=Power label = pow1149 (1.2*integ(I(v0),11.58N,11.59N)/0.01N)
.EXTRACT FILE=Power label = pow1150 (1.2*integ(I(v0),11.59N,11.6N)/0.01N)
.EXTRACT FILE=Power label = pow1151 (1.2*integ(I(v0),11.6N,11.61N)/0.01N)
.EXTRACT FILE=Power label = pow1152 (1.2*integ(I(v0),11.61N,11.62N)/0.01N)
.EXTRACT FILE=Power label = pow1153 (1.2*integ(I(v0),11.62N,11.63N)/0.01N)
.EXTRACT FILE=Power label = pow1154 (1.2*integ(I(v0),11.63N,11.64N)/0.01N)
.EXTRACT FILE=Power label = pow1155 (1.2*integ(I(v0),11.64N,11.65N)/0.01N)
.EXTRACT FILE=Power label = pow1156 (1.2*integ(I(v0),11.65N,11.66N)/0.01N)
.EXTRACT FILE=Power label = pow1157 (1.2*integ(I(v0),11.66N,11.67N)/0.01N)
.EXTRACT FILE=Power label = pow1158 (1.2*integ(I(v0),11.67N,11.68N)/0.01N)
.EXTRACT FILE=Power label = pow1159 (1.2*integ(I(v0),11.68N,11.69N)/0.01N)
.EXTRACT FILE=Power label = pow1160 (1.2*integ(I(v0),11.69N,11.7N)/0.01N)
.EXTRACT FILE=Power label = pow1161 (1.2*integ(I(v0),11.7N,11.71N)/0.01N)
.EXTRACT FILE=Power label = pow1162 (1.2*integ(I(v0),11.71N,11.72N)/0.01N)
.EXTRACT FILE=Power label = pow1163 (1.2*integ(I(v0),11.72N,11.73N)/0.01N)
.EXTRACT FILE=Power label = pow1164 (1.2*integ(I(v0),11.73N,11.74N)/0.01N)
.EXTRACT FILE=Power label = pow1165 (1.2*integ(I(v0),11.74N,11.75N)/0.01N)
.EXTRACT FILE=Power label = pow1166 (1.2*integ(I(v0),11.75N,11.76N)/0.01N)
.EXTRACT FILE=Power label = pow1167 (1.2*integ(I(v0),11.76N,11.77N)/0.01N)
.EXTRACT FILE=Power label = pow1168 (1.2*integ(I(v0),11.77N,11.78N)/0.01N)
.EXTRACT FILE=Power label = pow1169 (1.2*integ(I(v0),11.78N,11.79N)/0.01N)
.EXTRACT FILE=Power label = pow1170 (1.2*integ(I(v0),11.79N,11.8N)/0.01N)
.EXTRACT FILE=Power label = pow1171 (1.2*integ(I(v0),11.8N,11.81N)/0.01N)
.EXTRACT FILE=Power label = pow1172 (1.2*integ(I(v0),11.81N,11.82N)/0.01N)
.EXTRACT FILE=Power label = pow1173 (1.2*integ(I(v0),11.82N,11.83N)/0.01N)
.EXTRACT FILE=Power label = pow1174 (1.2*integ(I(v0),11.83N,11.84N)/0.01N)
.EXTRACT FILE=Power label = pow1175 (1.2*integ(I(v0),11.84N,11.85N)/0.01N)
.EXTRACT FILE=Power label = pow1176 (1.2*integ(I(v0),11.85N,11.86N)/0.01N)
.EXTRACT FILE=Power label = pow1177 (1.2*integ(I(v0),11.86N,11.87N)/0.01N)
.EXTRACT FILE=Power label = pow1178 (1.2*integ(I(v0),11.87N,11.88N)/0.01N)
.EXTRACT FILE=Power label = pow1179 (1.2*integ(I(v0),11.88N,11.89N)/0.01N)
.EXTRACT FILE=Power label = pow1180 (1.2*integ(I(v0),11.89N,11.9N)/0.01N)
.EXTRACT FILE=Power label = pow1181 (1.2*integ(I(v0),11.9N,11.91N)/0.01N)
.EXTRACT FILE=Power label = pow1182 (1.2*integ(I(v0),11.91N,11.92N)/0.01N)
.EXTRACT FILE=Power label = pow1183 (1.2*integ(I(v0),11.92N,11.93N)/0.01N)
.EXTRACT FILE=Power label = pow1184 (1.2*integ(I(v0),11.93N,11.94N)/0.01N)
.EXTRACT FILE=Power label = pow1185 (1.2*integ(I(v0),11.94N,11.95N)/0.01N)
.EXTRACT FILE=Power label = pow1186 (1.2*integ(I(v0),11.95N,11.96N)/0.01N)
.EXTRACT FILE=Power label = pow1187 (1.2*integ(I(v0),11.96N,11.97N)/0.01N)
.EXTRACT FILE=Power label = pow1188 (1.2*integ(I(v0),11.97N,11.98N)/0.01N)
.EXTRACT FILE=Power label = pow1189 (1.2*integ(I(v0),11.98N,11.99N)/0.01N)
.EXTRACT FILE=Power label = pow1190 (1.2*integ(I(v0),11.99N,12.0N)/0.01N)
.EXTRACT FILE=Power label = pow1191 (1.2*integ(I(v0),12.0N,12.01N)/0.01N)
.EXTRACT FILE=Power label = pow1192 (1.2*integ(I(v0),12.01N,12.02N)/0.01N)
.EXTRACT FILE=Power label = pow1193 (1.2*integ(I(v0),12.02N,12.03N)/0.01N)
.EXTRACT FILE=Power label = pow1194 (1.2*integ(I(v0),12.03N,12.04N)/0.01N)
.EXTRACT FILE=Power label = pow1195 (1.2*integ(I(v0),12.04N,12.05N)/0.01N)
.EXTRACT FILE=Power label = pow1196 (1.2*integ(I(v0),12.05N,12.06N)/0.01N)
.EXTRACT FILE=Power label = pow1197 (1.2*integ(I(v0),12.06N,12.07N)/0.01N)
.EXTRACT FILE=Power label = pow1198 (1.2*integ(I(v0),12.07N,12.08N)/0.01N)
.EXTRACT FILE=Power label = pow1199 (1.2*integ(I(v0),12.08N,12.09N)/0.01N)
.EXTRACT FILE=Power label = pow1200 (1.2*integ(I(v0),12.09N,12.1N)/0.01N)
.EXTRACT FILE=Power label = pow1201 (1.2*integ(I(v0),12.1N,12.11N)/0.01N)
.EXTRACT FILE=Power label = pow1202 (1.2*integ(I(v0),12.11N,12.12N)/0.01N)
.EXTRACT FILE=Power label = pow1203 (1.2*integ(I(v0),12.12N,12.13N)/0.01N)
.EXTRACT FILE=Power label = pow1204 (1.2*integ(I(v0),12.13N,12.14N)/0.01N)
.EXTRACT FILE=Power label = pow1205 (1.2*integ(I(v0),12.14N,12.15N)/0.01N)
.EXTRACT FILE=Power label = pow1206 (1.2*integ(I(v0),12.15N,12.16N)/0.01N)
.EXTRACT FILE=Power label = pow1207 (1.2*integ(I(v0),12.16N,12.17N)/0.01N)
.EXTRACT FILE=Power label = pow1208 (1.2*integ(I(v0),12.17N,12.18N)/0.01N)
.EXTRACT FILE=Power label = pow1209 (1.2*integ(I(v0),12.18N,12.19N)/0.01N)
.EXTRACT FILE=Power label = pow1210 (1.2*integ(I(v0),12.19N,12.2N)/0.01N)
.EXTRACT FILE=Power label = pow1211 (1.2*integ(I(v0),12.2N,12.21N)/0.01N)
.EXTRACT FILE=Power label = pow1212 (1.2*integ(I(v0),12.21N,12.22N)/0.01N)
.EXTRACT FILE=Power label = pow1213 (1.2*integ(I(v0),12.22N,12.23N)/0.01N)
.EXTRACT FILE=Power label = pow1214 (1.2*integ(I(v0),12.23N,12.24N)/0.01N)
.EXTRACT FILE=Power label = pow1215 (1.2*integ(I(v0),12.24N,12.25N)/0.01N)
.EXTRACT FILE=Power label = pow1216 (1.2*integ(I(v0),12.25N,12.26N)/0.01N)
.EXTRACT FILE=Power label = pow1217 (1.2*integ(I(v0),12.26N,12.27N)/0.01N)
.EXTRACT FILE=Power label = pow1218 (1.2*integ(I(v0),12.27N,12.28N)/0.01N)
.EXTRACT FILE=Power label = pow1219 (1.2*integ(I(v0),12.28N,12.29N)/0.01N)
.EXTRACT FILE=Power label = pow1220 (1.2*integ(I(v0),12.29N,12.3N)/0.01N)
.EXTRACT FILE=Power label = pow1221 (1.2*integ(I(v0),12.3N,12.31N)/0.01N)
.EXTRACT FILE=Power label = pow1222 (1.2*integ(I(v0),12.31N,12.32N)/0.01N)
.EXTRACT FILE=Power label = pow1223 (1.2*integ(I(v0),12.32N,12.33N)/0.01N)
.EXTRACT FILE=Power label = pow1224 (1.2*integ(I(v0),12.33N,12.34N)/0.01N)
.EXTRACT FILE=Power label = pow1225 (1.2*integ(I(v0),12.34N,12.35N)/0.01N)
.EXTRACT FILE=Power label = pow1226 (1.2*integ(I(v0),12.35N,12.36N)/0.01N)
.EXTRACT FILE=Power label = pow1227 (1.2*integ(I(v0),12.36N,12.37N)/0.01N)
.EXTRACT FILE=Power label = pow1228 (1.2*integ(I(v0),12.37N,12.38N)/0.01N)
.EXTRACT FILE=Power label = pow1229 (1.2*integ(I(v0),12.38N,12.39N)/0.01N)
.EXTRACT FILE=Power label = pow1230 (1.2*integ(I(v0),12.39N,12.4N)/0.01N)
.EXTRACT FILE=Power label = pow1231 (1.2*integ(I(v0),12.4N,12.41N)/0.01N)
.EXTRACT FILE=Power label = pow1232 (1.2*integ(I(v0),12.41N,12.42N)/0.01N)
.EXTRACT FILE=Power label = pow1233 (1.2*integ(I(v0),12.42N,12.43N)/0.01N)
.EXTRACT FILE=Power label = pow1234 (1.2*integ(I(v0),12.43N,12.44N)/0.01N)
.EXTRACT FILE=Power label = pow1235 (1.2*integ(I(v0),12.44N,12.45N)/0.01N)
.EXTRACT FILE=Power label = pow1236 (1.2*integ(I(v0),12.45N,12.46N)/0.01N)
.EXTRACT FILE=Power label = pow1237 (1.2*integ(I(v0),12.46N,12.47N)/0.01N)
.EXTRACT FILE=Power label = pow1238 (1.2*integ(I(v0),12.47N,12.48N)/0.01N)
.EXTRACT FILE=Power label = pow1239 (1.2*integ(I(v0),12.48N,12.49N)/0.01N)
.EXTRACT FILE=Power label = pow1240 (1.2*integ(I(v0),12.49N,12.5N)/0.01N)
.EXTRACT FILE=Power label = pow1241 (1.2*integ(I(v0),12.5N,12.51N)/0.01N)
.EXTRACT FILE=Power label = pow1242 (1.2*integ(I(v0),12.51N,12.52N)/0.01N)
.EXTRACT FILE=Power label = pow1243 (1.2*integ(I(v0),12.52N,12.53N)/0.01N)
.EXTRACT FILE=Power label = pow1244 (1.2*integ(I(v0),12.53N,12.54N)/0.01N)
.EXTRACT FILE=Power label = pow1245 (1.2*integ(I(v0),12.54N,12.55N)/0.01N)
.EXTRACT FILE=Power label = pow1246 (1.2*integ(I(v0),12.55N,12.56N)/0.01N)
.EXTRACT FILE=Power label = pow1247 (1.2*integ(I(v0),12.56N,12.57N)/0.01N)
.EXTRACT FILE=Power label = pow1248 (1.2*integ(I(v0),12.57N,12.58N)/0.01N)
.EXTRACT FILE=Power label = pow1249 (1.2*integ(I(v0),12.58N,12.59N)/0.01N)
.EXTRACT FILE=Power label = pow1250 (1.2*integ(I(v0),12.59N,12.6N)/0.01N)
.EXTRACT FILE=Power label = pow1251 (1.2*integ(I(v0),12.6N,12.61N)/0.01N)
.EXTRACT FILE=Power label = pow1252 (1.2*integ(I(v0),12.61N,12.62N)/0.01N)
.EXTRACT FILE=Power label = pow1253 (1.2*integ(I(v0),12.62N,12.63N)/0.01N)
.EXTRACT FILE=Power label = pow1254 (1.2*integ(I(v0),12.63N,12.64N)/0.01N)
.EXTRACT FILE=Power label = pow1255 (1.2*integ(I(v0),12.64N,12.65N)/0.01N)
.EXTRACT FILE=Power label = pow1256 (1.2*integ(I(v0),12.65N,12.66N)/0.01N)
.EXTRACT FILE=Power label = pow1257 (1.2*integ(I(v0),12.66N,12.67N)/0.01N)
.EXTRACT FILE=Power label = pow1258 (1.2*integ(I(v0),12.67N,12.68N)/0.01N)
.EXTRACT FILE=Power label = pow1259 (1.2*integ(I(v0),12.68N,12.69N)/0.01N)
.EXTRACT FILE=Power label = pow1260 (1.2*integ(I(v0),12.69N,12.7N)/0.01N)
.EXTRACT FILE=Power label = pow1261 (1.2*integ(I(v0),12.7N,12.71N)/0.01N)
.EXTRACT FILE=Power label = pow1262 (1.2*integ(I(v0),12.71N,12.72N)/0.01N)
.EXTRACT FILE=Power label = pow1263 (1.2*integ(I(v0),12.72N,12.73N)/0.01N)
.EXTRACT FILE=Power label = pow1264 (1.2*integ(I(v0),12.73N,12.74N)/0.01N)
.EXTRACT FILE=Power label = pow1265 (1.2*integ(I(v0),12.74N,12.75N)/0.01N)
.EXTRACT FILE=Power label = pow1266 (1.2*integ(I(v0),12.75N,12.76N)/0.01N)
.EXTRACT FILE=Power label = pow1267 (1.2*integ(I(v0),12.76N,12.77N)/0.01N)
.EXTRACT FILE=Power label = pow1268 (1.2*integ(I(v0),12.77N,12.78N)/0.01N)
.EXTRACT FILE=Power label = pow1269 (1.2*integ(I(v0),12.78N,12.79N)/0.01N)
.EXTRACT FILE=Power label = pow1270 (1.2*integ(I(v0),12.79N,12.8N)/0.01N)
.EXTRACT FILE=Power label = pow1271 (1.2*integ(I(v0),12.8N,12.81N)/0.01N)
.EXTRACT FILE=Power label = pow1272 (1.2*integ(I(v0),12.81N,12.82N)/0.01N)
.EXTRACT FILE=Power label = pow1273 (1.2*integ(I(v0),12.82N,12.83N)/0.01N)
.EXTRACT FILE=Power label = pow1274 (1.2*integ(I(v0),12.83N,12.84N)/0.01N)
.EXTRACT FILE=Power label = pow1275 (1.2*integ(I(v0),12.84N,12.85N)/0.01N)
.EXTRACT FILE=Power label = pow1276 (1.2*integ(I(v0),12.85N,12.86N)/0.01N)
.EXTRACT FILE=Power label = pow1277 (1.2*integ(I(v0),12.86N,12.87N)/0.01N)
.EXTRACT FILE=Power label = pow1278 (1.2*integ(I(v0),12.87N,12.88N)/0.01N)
.EXTRACT FILE=Power label = pow1279 (1.2*integ(I(v0),12.88N,12.89N)/0.01N)
.EXTRACT FILE=Power label = pow1280 (1.2*integ(I(v0),12.89N,12.9N)/0.01N)
.EXTRACT FILE=Power label = pow1281 (1.2*integ(I(v0),12.9N,12.91N)/0.01N)
.EXTRACT FILE=Power label = pow1282 (1.2*integ(I(v0),12.91N,12.92N)/0.01N)
.EXTRACT FILE=Power label = pow1283 (1.2*integ(I(v0),12.92N,12.93N)/0.01N)
.EXTRACT FILE=Power label = pow1284 (1.2*integ(I(v0),12.93N,12.94N)/0.01N)
.EXTRACT FILE=Power label = pow1285 (1.2*integ(I(v0),12.94N,12.95N)/0.01N)
.EXTRACT FILE=Power label = pow1286 (1.2*integ(I(v0),12.95N,12.96N)/0.01N)
.EXTRACT FILE=Power label = pow1287 (1.2*integ(I(v0),12.96N,12.97N)/0.01N)
.EXTRACT FILE=Power label = pow1288 (1.2*integ(I(v0),12.97N,12.98N)/0.01N)
.EXTRACT FILE=Power label = pow1289 (1.2*integ(I(v0),12.98N,12.99N)/0.01N)
.EXTRACT FILE=Power label = pow1290 (1.2*integ(I(v0),12.99N,13.0N)/0.01N)
.EXTRACT FILE=Power label = pow1291 (1.2*integ(I(v0),13.0N,13.01N)/0.01N)
.EXTRACT FILE=Power label = pow1292 (1.2*integ(I(v0),13.01N,13.02N)/0.01N)
.EXTRACT FILE=Power label = pow1293 (1.2*integ(I(v0),13.02N,13.03N)/0.01N)
.EXTRACT FILE=Power label = pow1294 (1.2*integ(I(v0),13.03N,13.04N)/0.01N)
.EXTRACT FILE=Power label = pow1295 (1.2*integ(I(v0),13.04N,13.05N)/0.01N)
.EXTRACT FILE=Power label = pow1296 (1.2*integ(I(v0),13.05N,13.06N)/0.01N)
.EXTRACT FILE=Power label = pow1297 (1.2*integ(I(v0),13.06N,13.07N)/0.01N)
.EXTRACT FILE=Power label = pow1298 (1.2*integ(I(v0),13.07N,13.08N)/0.01N)
.EXTRACT FILE=Power label = pow1299 (1.2*integ(I(v0),13.08N,13.09N)/0.01N)
.EXTRACT FILE=Power label = pow1300 (1.2*integ(I(v0),13.09N,13.1N)/0.01N)
.EXTRACT FILE=Power label = pow1301 (1.2*integ(I(v0),13.1N,13.11N)/0.01N)
.EXTRACT FILE=Power label = pow1302 (1.2*integ(I(v0),13.11N,13.12N)/0.01N)
.EXTRACT FILE=Power label = pow1303 (1.2*integ(I(v0),13.12N,13.13N)/0.01N)
.EXTRACT FILE=Power label = pow1304 (1.2*integ(I(v0),13.13N,13.14N)/0.01N)
.EXTRACT FILE=Power label = pow1305 (1.2*integ(I(v0),13.14N,13.15N)/0.01N)
.EXTRACT FILE=Power label = pow1306 (1.2*integ(I(v0),13.15N,13.16N)/0.01N)
.EXTRACT FILE=Power label = pow1307 (1.2*integ(I(v0),13.16N,13.17N)/0.01N)
.EXTRACT FILE=Power label = pow1308 (1.2*integ(I(v0),13.17N,13.18N)/0.01N)
.EXTRACT FILE=Power label = pow1309 (1.2*integ(I(v0),13.18N,13.19N)/0.01N)
.EXTRACT FILE=Power label = pow1310 (1.2*integ(I(v0),13.19N,13.2N)/0.01N)
.EXTRACT FILE=Power label = pow1311 (1.2*integ(I(v0),13.2N,13.21N)/0.01N)
.EXTRACT FILE=Power label = pow1312 (1.2*integ(I(v0),13.21N,13.22N)/0.01N)
.EXTRACT FILE=Power label = pow1313 (1.2*integ(I(v0),13.22N,13.23N)/0.01N)
.EXTRACT FILE=Power label = pow1314 (1.2*integ(I(v0),13.23N,13.24N)/0.01N)
.EXTRACT FILE=Power label = pow1315 (1.2*integ(I(v0),13.24N,13.25N)/0.01N)
.EXTRACT FILE=Power label = pow1316 (1.2*integ(I(v0),13.25N,13.26N)/0.01N)
.EXTRACT FILE=Power label = pow1317 (1.2*integ(I(v0),13.26N,13.27N)/0.01N)
.EXTRACT FILE=Power label = pow1318 (1.2*integ(I(v0),13.27N,13.28N)/0.01N)
.EXTRACT FILE=Power label = pow1319 (1.2*integ(I(v0),13.28N,13.29N)/0.01N)
.EXTRACT FILE=Power label = pow1320 (1.2*integ(I(v0),13.29N,13.3N)/0.01N)
.EXTRACT FILE=Power label = pow1321 (1.2*integ(I(v0),13.3N,13.31N)/0.01N)
.EXTRACT FILE=Power label = pow1322 (1.2*integ(I(v0),13.31N,13.32N)/0.01N)
.EXTRACT FILE=Power label = pow1323 (1.2*integ(I(v0),13.32N,13.33N)/0.01N)
.EXTRACT FILE=Power label = pow1324 (1.2*integ(I(v0),13.33N,13.34N)/0.01N)
.EXTRACT FILE=Power label = pow1325 (1.2*integ(I(v0),13.34N,13.35N)/0.01N)
.EXTRACT FILE=Power label = pow1326 (1.2*integ(I(v0),13.35N,13.36N)/0.01N)
.EXTRACT FILE=Power label = pow1327 (1.2*integ(I(v0),13.36N,13.37N)/0.01N)
.EXTRACT FILE=Power label = pow1328 (1.2*integ(I(v0),13.37N,13.38N)/0.01N)
.EXTRACT FILE=Power label = pow1329 (1.2*integ(I(v0),13.38N,13.39N)/0.01N)
.EXTRACT FILE=Power label = pow1330 (1.2*integ(I(v0),13.39N,13.4N)/0.01N)
.EXTRACT FILE=Power label = pow1331 (1.2*integ(I(v0),13.4N,13.41N)/0.01N)
.EXTRACT FILE=Power label = pow1332 (1.2*integ(I(v0),13.41N,13.42N)/0.01N)
.EXTRACT FILE=Power label = pow1333 (1.2*integ(I(v0),13.42N,13.43N)/0.01N)
.EXTRACT FILE=Power label = pow1334 (1.2*integ(I(v0),13.43N,13.44N)/0.01N)
.EXTRACT FILE=Power label = pow1335 (1.2*integ(I(v0),13.44N,13.45N)/0.01N)
.EXTRACT FILE=Power label = pow1336 (1.2*integ(I(v0),13.45N,13.46N)/0.01N)
.EXTRACT FILE=Power label = pow1337 (1.2*integ(I(v0),13.46N,13.47N)/0.01N)
.EXTRACT FILE=Power label = pow1338 (1.2*integ(I(v0),13.47N,13.48N)/0.01N)
.EXTRACT FILE=Power label = pow1339 (1.2*integ(I(v0),13.48N,13.49N)/0.01N)
.EXTRACT FILE=Power label = pow1340 (1.2*integ(I(v0),13.49N,13.5N)/0.01N)
.EXTRACT FILE=Power label = pow1341 (1.2*integ(I(v0),13.5N,13.51N)/0.01N)
.EXTRACT FILE=Power label = pow1342 (1.2*integ(I(v0),13.51N,13.52N)/0.01N)
.EXTRACT FILE=Power label = pow1343 (1.2*integ(I(v0),13.52N,13.53N)/0.01N)
.EXTRACT FILE=Power label = pow1344 (1.2*integ(I(v0),13.53N,13.54N)/0.01N)
.EXTRACT FILE=Power label = pow1345 (1.2*integ(I(v0),13.54N,13.55N)/0.01N)
.EXTRACT FILE=Power label = pow1346 (1.2*integ(I(v0),13.55N,13.56N)/0.01N)
.EXTRACT FILE=Power label = pow1347 (1.2*integ(I(v0),13.56N,13.57N)/0.01N)
.EXTRACT FILE=Power label = pow1348 (1.2*integ(I(v0),13.57N,13.58N)/0.01N)
.EXTRACT FILE=Power label = pow1349 (1.2*integ(I(v0),13.58N,13.59N)/0.01N)
.EXTRACT FILE=Power label = pow1350 (1.2*integ(I(v0),13.59N,13.6N)/0.01N)
.EXTRACT FILE=Power label = pow1351 (1.2*integ(I(v0),13.6N,13.61N)/0.01N)
.EXTRACT FILE=Power label = pow1352 (1.2*integ(I(v0),13.61N,13.62N)/0.01N)
.EXTRACT FILE=Power label = pow1353 (1.2*integ(I(v0),13.62N,13.63N)/0.01N)
.EXTRACT FILE=Power label = pow1354 (1.2*integ(I(v0),13.63N,13.64N)/0.01N)
.EXTRACT FILE=Power label = pow1355 (1.2*integ(I(v0),13.64N,13.65N)/0.01N)
.EXTRACT FILE=Power label = pow1356 (1.2*integ(I(v0),13.65N,13.66N)/0.01N)
.EXTRACT FILE=Power label = pow1357 (1.2*integ(I(v0),13.66N,13.67N)/0.01N)
.EXTRACT FILE=Power label = pow1358 (1.2*integ(I(v0),13.67N,13.68N)/0.01N)
.EXTRACT FILE=Power label = pow1359 (1.2*integ(I(v0),13.68N,13.69N)/0.01N)
.EXTRACT FILE=Power label = pow1360 (1.2*integ(I(v0),13.69N,13.7N)/0.01N)
.EXTRACT FILE=Power label = pow1361 (1.2*integ(I(v0),13.7N,13.71N)/0.01N)
.EXTRACT FILE=Power label = pow1362 (1.2*integ(I(v0),13.71N,13.72N)/0.01N)
.EXTRACT FILE=Power label = pow1363 (1.2*integ(I(v0),13.72N,13.73N)/0.01N)
.EXTRACT FILE=Power label = pow1364 (1.2*integ(I(v0),13.73N,13.74N)/0.01N)
.EXTRACT FILE=Power label = pow1365 (1.2*integ(I(v0),13.74N,13.75N)/0.01N)
.EXTRACT FILE=Power label = pow1366 (1.2*integ(I(v0),13.75N,13.76N)/0.01N)
.EXTRACT FILE=Power label = pow1367 (1.2*integ(I(v0),13.76N,13.77N)/0.01N)
.EXTRACT FILE=Power label = pow1368 (1.2*integ(I(v0),13.77N,13.78N)/0.01N)
.EXTRACT FILE=Power label = pow1369 (1.2*integ(I(v0),13.78N,13.79N)/0.01N)
.EXTRACT FILE=Power label = pow1370 (1.2*integ(I(v0),13.79N,13.8N)/0.01N)
.EXTRACT FILE=Power label = pow1371 (1.2*integ(I(v0),13.8N,13.81N)/0.01N)
.EXTRACT FILE=Power label = pow1372 (1.2*integ(I(v0),13.81N,13.82N)/0.01N)
.EXTRACT FILE=Power label = pow1373 (1.2*integ(I(v0),13.82N,13.83N)/0.01N)
.EXTRACT FILE=Power label = pow1374 (1.2*integ(I(v0),13.83N,13.84N)/0.01N)
.EXTRACT FILE=Power label = pow1375 (1.2*integ(I(v0),13.84N,13.85N)/0.01N)
.EXTRACT FILE=Power label = pow1376 (1.2*integ(I(v0),13.85N,13.86N)/0.01N)
.EXTRACT FILE=Power label = pow1377 (1.2*integ(I(v0),13.86N,13.87N)/0.01N)
.EXTRACT FILE=Power label = pow1378 (1.2*integ(I(v0),13.87N,13.88N)/0.01N)
.EXTRACT FILE=Power label = pow1379 (1.2*integ(I(v0),13.88N,13.89N)/0.01N)
.EXTRACT FILE=Power label = pow1380 (1.2*integ(I(v0),13.89N,13.9N)/0.01N)
.EXTRACT FILE=Power label = pow1381 (1.2*integ(I(v0),13.9N,13.91N)/0.01N)
.EXTRACT FILE=Power label = pow1382 (1.2*integ(I(v0),13.91N,13.92N)/0.01N)
.EXTRACT FILE=Power label = pow1383 (1.2*integ(I(v0),13.92N,13.93N)/0.01N)
.EXTRACT FILE=Power label = pow1384 (1.2*integ(I(v0),13.93N,13.94N)/0.01N)
.EXTRACT FILE=Power label = pow1385 (1.2*integ(I(v0),13.94N,13.95N)/0.01N)
.EXTRACT FILE=Power label = pow1386 (1.2*integ(I(v0),13.95N,13.96N)/0.01N)
.EXTRACT FILE=Power label = pow1387 (1.2*integ(I(v0),13.96N,13.97N)/0.01N)
.EXTRACT FILE=Power label = pow1388 (1.2*integ(I(v0),13.97N,13.98N)/0.01N)
.EXTRACT FILE=Power label = pow1389 (1.2*integ(I(v0),13.98N,13.99N)/0.01N)
.EXTRACT FILE=Power label = pow1390 (1.2*integ(I(v0),13.99N,14.0N)/0.01N)
.EXTRACT FILE=Power label = pow1391 (1.2*integ(I(v0),14.0N,14.01N)/0.01N)
.EXTRACT FILE=Power label = pow1392 (1.2*integ(I(v0),14.01N,14.02N)/0.01N)
.EXTRACT FILE=Power label = pow1393 (1.2*integ(I(v0),14.02N,14.03N)/0.01N)
.EXTRACT FILE=Power label = pow1394 (1.2*integ(I(v0),14.03N,14.04N)/0.01N)
.EXTRACT FILE=Power label = pow1395 (1.2*integ(I(v0),14.04N,14.05N)/0.01N)
.EXTRACT FILE=Power label = pow1396 (1.2*integ(I(v0),14.05N,14.06N)/0.01N)
.EXTRACT FILE=Power label = pow1397 (1.2*integ(I(v0),14.06N,14.07N)/0.01N)
.EXTRACT FILE=Power label = pow1398 (1.2*integ(I(v0),14.07N,14.08N)/0.01N)
.EXTRACT FILE=Power label = pow1399 (1.2*integ(I(v0),14.08N,14.09N)/0.01N)
.EXTRACT FILE=Power label = pow1400 (1.2*integ(I(v0),14.09N,14.1N)/0.01N)
.EXTRACT FILE=Power label = pow1401 (1.2*integ(I(v0),14.1N,14.11N)/0.01N)
.EXTRACT FILE=Power label = pow1402 (1.2*integ(I(v0),14.11N,14.12N)/0.01N)
.EXTRACT FILE=Power label = pow1403 (1.2*integ(I(v0),14.12N,14.13N)/0.01N)
.EXTRACT FILE=Power label = pow1404 (1.2*integ(I(v0),14.13N,14.14N)/0.01N)
.EXTRACT FILE=Power label = pow1405 (1.2*integ(I(v0),14.14N,14.15N)/0.01N)
.EXTRACT FILE=Power label = pow1406 (1.2*integ(I(v0),14.15N,14.16N)/0.01N)
.EXTRACT FILE=Power label = pow1407 (1.2*integ(I(v0),14.16N,14.17N)/0.01N)
.EXTRACT FILE=Power label = pow1408 (1.2*integ(I(v0),14.17N,14.18N)/0.01N)
.EXTRACT FILE=Power label = pow1409 (1.2*integ(I(v0),14.18N,14.19N)/0.01N)
.EXTRACT FILE=Power label = pow1410 (1.2*integ(I(v0),14.19N,14.2N)/0.01N)
.EXTRACT FILE=Power label = pow1411 (1.2*integ(I(v0),14.2N,14.21N)/0.01N)
.EXTRACT FILE=Power label = pow1412 (1.2*integ(I(v0),14.21N,14.22N)/0.01N)
.EXTRACT FILE=Power label = pow1413 (1.2*integ(I(v0),14.22N,14.23N)/0.01N)
.EXTRACT FILE=Power label = pow1414 (1.2*integ(I(v0),14.23N,14.24N)/0.01N)
.EXTRACT FILE=Power label = pow1415 (1.2*integ(I(v0),14.24N,14.25N)/0.01N)
.EXTRACT FILE=Power label = pow1416 (1.2*integ(I(v0),14.25N,14.26N)/0.01N)
.EXTRACT FILE=Power label = pow1417 (1.2*integ(I(v0),14.26N,14.27N)/0.01N)
.EXTRACT FILE=Power label = pow1418 (1.2*integ(I(v0),14.27N,14.28N)/0.01N)
.EXTRACT FILE=Power label = pow1419 (1.2*integ(I(v0),14.28N,14.29N)/0.01N)
.EXTRACT FILE=Power label = pow1420 (1.2*integ(I(v0),14.29N,14.3N)/0.01N)
.EXTRACT FILE=Power label = pow1421 (1.2*integ(I(v0),14.3N,14.31N)/0.01N)
.EXTRACT FILE=Power label = pow1422 (1.2*integ(I(v0),14.31N,14.32N)/0.01N)
.EXTRACT FILE=Power label = pow1423 (1.2*integ(I(v0),14.32N,14.33N)/0.01N)
.EXTRACT FILE=Power label = pow1424 (1.2*integ(I(v0),14.33N,14.34N)/0.01N)
.EXTRACT FILE=Power label = pow1425 (1.2*integ(I(v0),14.34N,14.35N)/0.01N)
.EXTRACT FILE=Power label = pow1426 (1.2*integ(I(v0),14.35N,14.36N)/0.01N)
.EXTRACT FILE=Power label = pow1427 (1.2*integ(I(v0),14.36N,14.37N)/0.01N)
.EXTRACT FILE=Power label = pow1428 (1.2*integ(I(v0),14.37N,14.38N)/0.01N)
.EXTRACT FILE=Power label = pow1429 (1.2*integ(I(v0),14.38N,14.39N)/0.01N)
.EXTRACT FILE=Power label = pow1430 (1.2*integ(I(v0),14.39N,14.4N)/0.01N)
.EXTRACT FILE=Power label = pow1431 (1.2*integ(I(v0),14.4N,14.41N)/0.01N)
.EXTRACT FILE=Power label = pow1432 (1.2*integ(I(v0),14.41N,14.42N)/0.01N)
.EXTRACT FILE=Power label = pow1433 (1.2*integ(I(v0),14.42N,14.43N)/0.01N)
.EXTRACT FILE=Power label = pow1434 (1.2*integ(I(v0),14.43N,14.44N)/0.01N)
.EXTRACT FILE=Power label = pow1435 (1.2*integ(I(v0),14.44N,14.45N)/0.01N)
.EXTRACT FILE=Power label = pow1436 (1.2*integ(I(v0),14.45N,14.46N)/0.01N)
.EXTRACT FILE=Power label = pow1437 (1.2*integ(I(v0),14.46N,14.47N)/0.01N)
.EXTRACT FILE=Power label = pow1438 (1.2*integ(I(v0),14.47N,14.48N)/0.01N)
.EXTRACT FILE=Power label = pow1439 (1.2*integ(I(v0),14.48N,14.49N)/0.01N)
.EXTRACT FILE=Power label = pow1440 (1.2*integ(I(v0),14.49N,14.5N)/0.01N)
.EXTRACT FILE=Power label = pow1441 (1.2*integ(I(v0),14.5N,14.51N)/0.01N)
.EXTRACT FILE=Power label = pow1442 (1.2*integ(I(v0),14.51N,14.52N)/0.01N)
.EXTRACT FILE=Power label = pow1443 (1.2*integ(I(v0),14.52N,14.53N)/0.01N)
.EXTRACT FILE=Power label = pow1444 (1.2*integ(I(v0),14.53N,14.54N)/0.01N)
.EXTRACT FILE=Power label = pow1445 (1.2*integ(I(v0),14.54N,14.55N)/0.01N)
.EXTRACT FILE=Power label = pow1446 (1.2*integ(I(v0),14.55N,14.56N)/0.01N)
.EXTRACT FILE=Power label = pow1447 (1.2*integ(I(v0),14.56N,14.57N)/0.01N)
.EXTRACT FILE=Power label = pow1448 (1.2*integ(I(v0),14.57N,14.58N)/0.01N)
.EXTRACT FILE=Power label = pow1449 (1.2*integ(I(v0),14.58N,14.59N)/0.01N)
.EXTRACT FILE=Power label = pow1450 (1.2*integ(I(v0),14.59N,14.6N)/0.01N)
.EXTRACT FILE=Power label = pow1451 (1.2*integ(I(v0),14.6N,14.61N)/0.01N)
.EXTRACT FILE=Power label = pow1452 (1.2*integ(I(v0),14.61N,14.62N)/0.01N)
.EXTRACT FILE=Power label = pow1453 (1.2*integ(I(v0),14.62N,14.63N)/0.01N)
.EXTRACT FILE=Power label = pow1454 (1.2*integ(I(v0),14.63N,14.64N)/0.01N)
.EXTRACT FILE=Power label = pow1455 (1.2*integ(I(v0),14.64N,14.65N)/0.01N)
.EXTRACT FILE=Power label = pow1456 (1.2*integ(I(v0),14.65N,14.66N)/0.01N)
.EXTRACT FILE=Power label = pow1457 (1.2*integ(I(v0),14.66N,14.67N)/0.01N)
.EXTRACT FILE=Power label = pow1458 (1.2*integ(I(v0),14.67N,14.68N)/0.01N)
.EXTRACT FILE=Power label = pow1459 (1.2*integ(I(v0),14.68N,14.69N)/0.01N)
.EXTRACT FILE=Power label = pow1460 (1.2*integ(I(v0),14.69N,14.7N)/0.01N)
.EXTRACT FILE=Power label = pow1461 (1.2*integ(I(v0),14.7N,14.71N)/0.01N)
.EXTRACT FILE=Power label = pow1462 (1.2*integ(I(v0),14.71N,14.72N)/0.01N)
.EXTRACT FILE=Power label = pow1463 (1.2*integ(I(v0),14.72N,14.73N)/0.01N)
.EXTRACT FILE=Power label = pow1464 (1.2*integ(I(v0),14.73N,14.74N)/0.01N)
.EXTRACT FILE=Power label = pow1465 (1.2*integ(I(v0),14.74N,14.75N)/0.01N)
.EXTRACT FILE=Power label = pow1466 (1.2*integ(I(v0),14.75N,14.76N)/0.01N)
.EXTRACT FILE=Power label = pow1467 (1.2*integ(I(v0),14.76N,14.77N)/0.01N)
.EXTRACT FILE=Power label = pow1468 (1.2*integ(I(v0),14.77N,14.78N)/0.01N)
.EXTRACT FILE=Power label = pow1469 (1.2*integ(I(v0),14.78N,14.79N)/0.01N)
.EXTRACT FILE=Power label = pow1470 (1.2*integ(I(v0),14.79N,14.8N)/0.01N)
.EXTRACT FILE=Power label = pow1471 (1.2*integ(I(v0),14.8N,14.81N)/0.01N)
.EXTRACT FILE=Power label = pow1472 (1.2*integ(I(v0),14.81N,14.82N)/0.01N)
.EXTRACT FILE=Power label = pow1473 (1.2*integ(I(v0),14.82N,14.83N)/0.01N)
.EXTRACT FILE=Power label = pow1474 (1.2*integ(I(v0),14.83N,14.84N)/0.01N)
.EXTRACT FILE=Power label = pow1475 (1.2*integ(I(v0),14.84N,14.85N)/0.01N)
.EXTRACT FILE=Power label = pow1476 (1.2*integ(I(v0),14.85N,14.86N)/0.01N)
.EXTRACT FILE=Power label = pow1477 (1.2*integ(I(v0),14.86N,14.87N)/0.01N)
.EXTRACT FILE=Power label = pow1478 (1.2*integ(I(v0),14.87N,14.88N)/0.01N)
.EXTRACT FILE=Power label = pow1479 (1.2*integ(I(v0),14.88N,14.89N)/0.01N)
.EXTRACT FILE=Power label = pow1480 (1.2*integ(I(v0),14.89N,14.9N)/0.01N)
.EXTRACT FILE=Power label = pow1481 (1.2*integ(I(v0),14.9N,14.91N)/0.01N)
.EXTRACT FILE=Power label = pow1482 (1.2*integ(I(v0),14.91N,14.92N)/0.01N)
.EXTRACT FILE=Power label = pow1483 (1.2*integ(I(v0),14.92N,14.93N)/0.01N)
.EXTRACT FILE=Power label = pow1484 (1.2*integ(I(v0),14.93N,14.94N)/0.01N)
.EXTRACT FILE=Power label = pow1485 (1.2*integ(I(v0),14.94N,14.95N)/0.01N)
.EXTRACT FILE=Power label = pow1486 (1.2*integ(I(v0),14.95N,14.96N)/0.01N)
.EXTRACT FILE=Power label = pow1487 (1.2*integ(I(v0),14.96N,14.97N)/0.01N)
.EXTRACT FILE=Power label = pow1488 (1.2*integ(I(v0),14.97N,14.98N)/0.01N)
.EXTRACT FILE=Power label = pow1489 (1.2*integ(I(v0),14.98N,14.99N)/0.01N)
.EXTRACT FILE=Power label = pow1490 (1.2*integ(I(v0),14.99N,15.0N)/0.01N)
.EXTRACT FILE=Power label = pow1491 (1.2*integ(I(v0),15.0N,15.01N)/0.01N)
.EXTRACT FILE=Power label = pow1492 (1.2*integ(I(v0),15.01N,15.02N)/0.01N)
.EXTRACT FILE=Power label = pow1493 (1.2*integ(I(v0),15.02N,15.03N)/0.01N)
.EXTRACT FILE=Power label = pow1494 (1.2*integ(I(v0),15.03N,15.04N)/0.01N)
.EXTRACT FILE=Power label = pow1495 (1.2*integ(I(v0),15.04N,15.05N)/0.01N)
.EXTRACT FILE=Power label = pow1496 (1.2*integ(I(v0),15.05N,15.06N)/0.01N)
.EXTRACT FILE=Power label = pow1497 (1.2*integ(I(v0),15.06N,15.07N)/0.01N)
.EXTRACT FILE=Power label = pow1498 (1.2*integ(I(v0),15.07N,15.08N)/0.01N)
.EXTRACT FILE=Power label = pow1499 (1.2*integ(I(v0),15.08N,15.09N)/0.01N)
.EXTRACT FILE=Power label = pow1500 (1.2*integ(I(v0),15.09N,15.1N)/0.01N)
.EXTRACT FILE=Power label = pow1501 (1.2*integ(I(v0),15.1N,15.11N)/0.01N)
.EXTRACT FILE=Power label = pow1502 (1.2*integ(I(v0),15.11N,15.12N)/0.01N)
.EXTRACT FILE=Power label = pow1503 (1.2*integ(I(v0),15.12N,15.13N)/0.01N)
.EXTRACT FILE=Power label = pow1504 (1.2*integ(I(v0),15.13N,15.14N)/0.01N)
.EXTRACT FILE=Power label = pow1505 (1.2*integ(I(v0),15.14N,15.15N)/0.01N)
.EXTRACT FILE=Power label = pow1506 (1.2*integ(I(v0),15.15N,15.16N)/0.01N)
.EXTRACT FILE=Power label = pow1507 (1.2*integ(I(v0),15.16N,15.17N)/0.01N)
.EXTRACT FILE=Power label = pow1508 (1.2*integ(I(v0),15.17N,15.18N)/0.01N)
.EXTRACT FILE=Power label = pow1509 (1.2*integ(I(v0),15.18N,15.19N)/0.01N)
.EXTRACT FILE=Power label = pow1510 (1.2*integ(I(v0),15.19N,15.2N)/0.01N)
.EXTRACT FILE=Power label = pow1511 (1.2*integ(I(v0),15.2N,15.21N)/0.01N)
.EXTRACT FILE=Power label = pow1512 (1.2*integ(I(v0),15.21N,15.22N)/0.01N)
.EXTRACT FILE=Power label = pow1513 (1.2*integ(I(v0),15.22N,15.23N)/0.01N)
.EXTRACT FILE=Power label = pow1514 (1.2*integ(I(v0),15.23N,15.24N)/0.01N)
.EXTRACT FILE=Power label = pow1515 (1.2*integ(I(v0),15.24N,15.25N)/0.01N)
.EXTRACT FILE=Power label = pow1516 (1.2*integ(I(v0),15.25N,15.26N)/0.01N)
.EXTRACT FILE=Power label = pow1517 (1.2*integ(I(v0),15.26N,15.27N)/0.01N)
.EXTRACT FILE=Power label = pow1518 (1.2*integ(I(v0),15.27N,15.28N)/0.01N)
.EXTRACT FILE=Power label = pow1519 (1.2*integ(I(v0),15.28N,15.29N)/0.01N)
.EXTRACT FILE=Power label = pow1520 (1.2*integ(I(v0),15.29N,15.3N)/0.01N)
.EXTRACT FILE=Power label = pow1521 (1.2*integ(I(v0),15.3N,15.31N)/0.01N)
.EXTRACT FILE=Power label = pow1522 (1.2*integ(I(v0),15.31N,15.32N)/0.01N)
.EXTRACT FILE=Power label = pow1523 (1.2*integ(I(v0),15.32N,15.33N)/0.01N)
.EXTRACT FILE=Power label = pow1524 (1.2*integ(I(v0),15.33N,15.34N)/0.01N)
.EXTRACT FILE=Power label = pow1525 (1.2*integ(I(v0),15.34N,15.35N)/0.01N)
.EXTRACT FILE=Power label = pow1526 (1.2*integ(I(v0),15.35N,15.36N)/0.01N)
.EXTRACT FILE=Power label = pow1527 (1.2*integ(I(v0),15.36N,15.37N)/0.01N)
.EXTRACT FILE=Power label = pow1528 (1.2*integ(I(v0),15.37N,15.38N)/0.01N)
.EXTRACT FILE=Power label = pow1529 (1.2*integ(I(v0),15.38N,15.39N)/0.01N)
.EXTRACT FILE=Power label = pow1530 (1.2*integ(I(v0),15.39N,15.4N)/0.01N)
.EXTRACT FILE=Power label = pow1531 (1.2*integ(I(v0),15.4N,15.41N)/0.01N)
.EXTRACT FILE=Power label = pow1532 (1.2*integ(I(v0),15.41N,15.42N)/0.01N)
.EXTRACT FILE=Power label = pow1533 (1.2*integ(I(v0),15.42N,15.43N)/0.01N)
.EXTRACT FILE=Power label = pow1534 (1.2*integ(I(v0),15.43N,15.44N)/0.01N)
.EXTRACT FILE=Power label = pow1535 (1.2*integ(I(v0),15.44N,15.45N)/0.01N)
.EXTRACT FILE=Power label = pow1536 (1.2*integ(I(v0),15.45N,15.46N)/0.01N)
.EXTRACT FILE=Power label = pow1537 (1.2*integ(I(v0),15.46N,15.47N)/0.01N)
.EXTRACT FILE=Power label = pow1538 (1.2*integ(I(v0),15.47N,15.48N)/0.01N)
.EXTRACT FILE=Power label = pow1539 (1.2*integ(I(v0),15.48N,15.49N)/0.01N)
.EXTRACT FILE=Power label = pow1540 (1.2*integ(I(v0),15.49N,15.5N)/0.01N)
.EXTRACT FILE=Power label = pow1541 (1.2*integ(I(v0),15.5N,15.51N)/0.01N)
.EXTRACT FILE=Power label = pow1542 (1.2*integ(I(v0),15.51N,15.52N)/0.01N)
.EXTRACT FILE=Power label = pow1543 (1.2*integ(I(v0),15.52N,15.53N)/0.01N)
.EXTRACT FILE=Power label = pow1544 (1.2*integ(I(v0),15.53N,15.54N)/0.01N)
.EXTRACT FILE=Power label = pow1545 (1.2*integ(I(v0),15.54N,15.55N)/0.01N)
.EXTRACT FILE=Power label = pow1546 (1.2*integ(I(v0),15.55N,15.56N)/0.01N)
.EXTRACT FILE=Power label = pow1547 (1.2*integ(I(v0),15.56N,15.57N)/0.01N)
.EXTRACT FILE=Power label = pow1548 (1.2*integ(I(v0),15.57N,15.58N)/0.01N)
.EXTRACT FILE=Power label = pow1549 (1.2*integ(I(v0),15.58N,15.59N)/0.01N)
.EXTRACT FILE=Power label = pow1550 (1.2*integ(I(v0),15.59N,15.6N)/0.01N)
.EXTRACT FILE=Power label = pow1551 (1.2*integ(I(v0),15.6N,15.61N)/0.01N)
.EXTRACT FILE=Power label = pow1552 (1.2*integ(I(v0),15.61N,15.62N)/0.01N)
.EXTRACT FILE=Power label = pow1553 (1.2*integ(I(v0),15.62N,15.63N)/0.01N)
.EXTRACT FILE=Power label = pow1554 (1.2*integ(I(v0),15.63N,15.64N)/0.01N)
.EXTRACT FILE=Power label = pow1555 (1.2*integ(I(v0),15.64N,15.65N)/0.01N)
.EXTRACT FILE=Power label = pow1556 (1.2*integ(I(v0),15.65N,15.66N)/0.01N)
.EXTRACT FILE=Power label = pow1557 (1.2*integ(I(v0),15.66N,15.67N)/0.01N)
.EXTRACT FILE=Power label = pow1558 (1.2*integ(I(v0),15.67N,15.68N)/0.01N)
.EXTRACT FILE=Power label = pow1559 (1.2*integ(I(v0),15.68N,15.69N)/0.01N)
.EXTRACT FILE=Power label = pow1560 (1.2*integ(I(v0),15.69N,15.7N)/0.01N)
.EXTRACT FILE=Power label = pow1561 (1.2*integ(I(v0),15.7N,15.71N)/0.01N)
.EXTRACT FILE=Power label = pow1562 (1.2*integ(I(v0),15.71N,15.72N)/0.01N)
.EXTRACT FILE=Power label = pow1563 (1.2*integ(I(v0),15.72N,15.73N)/0.01N)
.EXTRACT FILE=Power label = pow1564 (1.2*integ(I(v0),15.73N,15.74N)/0.01N)
.EXTRACT FILE=Power label = pow1565 (1.2*integ(I(v0),15.74N,15.75N)/0.01N)
.EXTRACT FILE=Power label = pow1566 (1.2*integ(I(v0),15.75N,15.76N)/0.01N)
.EXTRACT FILE=Power label = pow1567 (1.2*integ(I(v0),15.76N,15.77N)/0.01N)
.EXTRACT FILE=Power label = pow1568 (1.2*integ(I(v0),15.77N,15.78N)/0.01N)
.EXTRACT FILE=Power label = pow1569 (1.2*integ(I(v0),15.78N,15.79N)/0.01N)
.EXTRACT FILE=Power label = pow1570 (1.2*integ(I(v0),15.79N,15.8N)/0.01N)
.EXTRACT FILE=Power label = pow1571 (1.2*integ(I(v0),15.8N,15.81N)/0.01N)
.EXTRACT FILE=Power label = pow1572 (1.2*integ(I(v0),15.81N,15.82N)/0.01N)
.EXTRACT FILE=Power label = pow1573 (1.2*integ(I(v0),15.82N,15.83N)/0.01N)
.EXTRACT FILE=Power label = pow1574 (1.2*integ(I(v0),15.83N,15.84N)/0.01N)
.EXTRACT FILE=Power label = pow1575 (1.2*integ(I(v0),15.84N,15.85N)/0.01N)
.EXTRACT FILE=Power label = pow1576 (1.2*integ(I(v0),15.85N,15.86N)/0.01N)
.EXTRACT FILE=Power label = pow1577 (1.2*integ(I(v0),15.86N,15.87N)/0.01N)
.EXTRACT FILE=Power label = pow1578 (1.2*integ(I(v0),15.87N,15.88N)/0.01N)
.EXTRACT FILE=Power label = pow1579 (1.2*integ(I(v0),15.88N,15.89N)/0.01N)
.EXTRACT FILE=Power label = pow1580 (1.2*integ(I(v0),15.89N,15.9N)/0.01N)
.EXTRACT FILE=Power label = pow1581 (1.2*integ(I(v0),15.9N,15.91N)/0.01N)
.EXTRACT FILE=Power label = pow1582 (1.2*integ(I(v0),15.91N,15.92N)/0.01N)
.EXTRACT FILE=Power label = pow1583 (1.2*integ(I(v0),15.92N,15.93N)/0.01N)
.EXTRACT FILE=Power label = pow1584 (1.2*integ(I(v0),15.93N,15.94N)/0.01N)
.EXTRACT FILE=Power label = pow1585 (1.2*integ(I(v0),15.94N,15.95N)/0.01N)
.EXTRACT FILE=Power label = pow1586 (1.2*integ(I(v0),15.95N,15.96N)/0.01N)
.EXTRACT FILE=Power label = pow1587 (1.2*integ(I(v0),15.96N,15.97N)/0.01N)
.EXTRACT FILE=Power label = pow1588 (1.2*integ(I(v0),15.97N,15.98N)/0.01N)
.EXTRACT FILE=Power label = pow1589 (1.2*integ(I(v0),15.98N,15.99N)/0.01N)
.EXTRACT FILE=Power label = pow1590 (1.2*integ(I(v0),15.99N,16.0N)/0.01N)
.EXTRACT FILE=Power label = pow1591 (1.2*integ(I(v0),16.0N,16.01N)/0.01N)
.EXTRACT FILE=Power label = pow1592 (1.2*integ(I(v0),16.01N,16.02N)/0.01N)
.EXTRACT FILE=Power label = pow1593 (1.2*integ(I(v0),16.02N,16.03N)/0.01N)
.EXTRACT FILE=Power label = pow1594 (1.2*integ(I(v0),16.03N,16.04N)/0.01N)
.EXTRACT FILE=Power label = pow1595 (1.2*integ(I(v0),16.04N,16.05N)/0.01N)
.EXTRACT FILE=Power label = pow1596 (1.2*integ(I(v0),16.05N,16.06N)/0.01N)
.EXTRACT FILE=Power label = pow1597 (1.2*integ(I(v0),16.06N,16.07N)/0.01N)
.EXTRACT FILE=Power label = pow1598 (1.2*integ(I(v0),16.07N,16.08N)/0.01N)
.EXTRACT FILE=Power label = pow1599 (1.2*integ(I(v0),16.08N,16.09N)/0.01N)
.EXTRACT FILE=Power label = pow1600 (1.2*integ(I(v0),16.09N,16.1N)/0.01N)
.EXTRACT FILE=Power label = pow1601 (1.2*integ(I(v0),16.1N,16.11N)/0.01N)
.EXTRACT FILE=Power label = pow1602 (1.2*integ(I(v0),16.11N,16.12N)/0.01N)
.EXTRACT FILE=Power label = pow1603 (1.2*integ(I(v0),16.12N,16.13N)/0.01N)
.EXTRACT FILE=Power label = pow1604 (1.2*integ(I(v0),16.13N,16.14N)/0.01N)
.EXTRACT FILE=Power label = pow1605 (1.2*integ(I(v0),16.14N,16.15N)/0.01N)
.EXTRACT FILE=Power label = pow1606 (1.2*integ(I(v0),16.15N,16.16N)/0.01N)
.EXTRACT FILE=Power label = pow1607 (1.2*integ(I(v0),16.16N,16.17N)/0.01N)
.EXTRACT FILE=Power label = pow1608 (1.2*integ(I(v0),16.17N,16.18N)/0.01N)
.EXTRACT FILE=Power label = pow1609 (1.2*integ(I(v0),16.18N,16.19N)/0.01N)
.EXTRACT FILE=Power label = pow1610 (1.2*integ(I(v0),16.19N,16.2N)/0.01N)
.EXTRACT FILE=Power label = pow1611 (1.2*integ(I(v0),16.2N,16.21N)/0.01N)
.EXTRACT FILE=Power label = pow1612 (1.2*integ(I(v0),16.21N,16.22N)/0.01N)
.EXTRACT FILE=Power label = pow1613 (1.2*integ(I(v0),16.22N,16.23N)/0.01N)
.EXTRACT FILE=Power label = pow1614 (1.2*integ(I(v0),16.23N,16.24N)/0.01N)
.EXTRACT FILE=Power label = pow1615 (1.2*integ(I(v0),16.24N,16.25N)/0.01N)
.EXTRACT FILE=Power label = pow1616 (1.2*integ(I(v0),16.25N,16.26N)/0.01N)
.EXTRACT FILE=Power label = pow1617 (1.2*integ(I(v0),16.26N,16.27N)/0.01N)
.EXTRACT FILE=Power label = pow1618 (1.2*integ(I(v0),16.27N,16.28N)/0.01N)
.EXTRACT FILE=Power label = pow1619 (1.2*integ(I(v0),16.28N,16.29N)/0.01N)
.EXTRACT FILE=Power label = pow1620 (1.2*integ(I(v0),16.29N,16.3N)/0.01N)
.EXTRACT FILE=Power label = pow1621 (1.2*integ(I(v0),16.3N,16.31N)/0.01N)
.EXTRACT FILE=Power label = pow1622 (1.2*integ(I(v0),16.31N,16.32N)/0.01N)
.EXTRACT FILE=Power label = pow1623 (1.2*integ(I(v0),16.32N,16.33N)/0.01N)
.EXTRACT FILE=Power label = pow1624 (1.2*integ(I(v0),16.33N,16.34N)/0.01N)
.EXTRACT FILE=Power label = pow1625 (1.2*integ(I(v0),16.34N,16.35N)/0.01N)
.EXTRACT FILE=Power label = pow1626 (1.2*integ(I(v0),16.35N,16.36N)/0.01N)
.EXTRACT FILE=Power label = pow1627 (1.2*integ(I(v0),16.36N,16.37N)/0.01N)
.EXTRACT FILE=Power label = pow1628 (1.2*integ(I(v0),16.37N,16.38N)/0.01N)
.EXTRACT FILE=Power label = pow1629 (1.2*integ(I(v0),16.38N,16.39N)/0.01N)
.EXTRACT FILE=Power label = pow1630 (1.2*integ(I(v0),16.39N,16.4N)/0.01N)
.EXTRACT FILE=Power label = pow1631 (1.2*integ(I(v0),16.4N,16.41N)/0.01N)
.EXTRACT FILE=Power label = pow1632 (1.2*integ(I(v0),16.41N,16.42N)/0.01N)
.EXTRACT FILE=Power label = pow1633 (1.2*integ(I(v0),16.42N,16.43N)/0.01N)
.EXTRACT FILE=Power label = pow1634 (1.2*integ(I(v0),16.43N,16.44N)/0.01N)
.EXTRACT FILE=Power label = pow1635 (1.2*integ(I(v0),16.44N,16.45N)/0.01N)
.EXTRACT FILE=Power label = pow1636 (1.2*integ(I(v0),16.45N,16.46N)/0.01N)
.EXTRACT FILE=Power label = pow1637 (1.2*integ(I(v0),16.46N,16.47N)/0.01N)
.EXTRACT FILE=Power label = pow1638 (1.2*integ(I(v0),16.47N,16.48N)/0.01N)
.EXTRACT FILE=Power label = pow1639 (1.2*integ(I(v0),16.48N,16.49N)/0.01N)
.EXTRACT FILE=Power label = pow1640 (1.2*integ(I(v0),16.49N,16.5N)/0.01N)
.EXTRACT FILE=Power label = pow1641 (1.2*integ(I(v0),16.5N,16.51N)/0.01N)
.EXTRACT FILE=Power label = pow1642 (1.2*integ(I(v0),16.51N,16.52N)/0.01N)
.EXTRACT FILE=Power label = pow1643 (1.2*integ(I(v0),16.52N,16.53N)/0.01N)
.EXTRACT FILE=Power label = pow1644 (1.2*integ(I(v0),16.53N,16.54N)/0.01N)
.EXTRACT FILE=Power label = pow1645 (1.2*integ(I(v0),16.54N,16.55N)/0.01N)
.EXTRACT FILE=Power label = pow1646 (1.2*integ(I(v0),16.55N,16.56N)/0.01N)
.EXTRACT FILE=Power label = pow1647 (1.2*integ(I(v0),16.56N,16.57N)/0.01N)
.EXTRACT FILE=Power label = pow1648 (1.2*integ(I(v0),16.57N,16.58N)/0.01N)
.EXTRACT FILE=Power label = pow1649 (1.2*integ(I(v0),16.58N,16.59N)/0.01N)
.EXTRACT FILE=Power label = pow1650 (1.2*integ(I(v0),16.59N,16.6N)/0.01N)
.EXTRACT FILE=Power label = pow1651 (1.2*integ(I(v0),16.6N,16.61N)/0.01N)
.EXTRACT FILE=Power label = pow1652 (1.2*integ(I(v0),16.61N,16.62N)/0.01N)
.EXTRACT FILE=Power label = pow1653 (1.2*integ(I(v0),16.62N,16.63N)/0.01N)
.EXTRACT FILE=Power label = pow1654 (1.2*integ(I(v0),16.63N,16.64N)/0.01N)
.EXTRACT FILE=Power label = pow1655 (1.2*integ(I(v0),16.64N,16.65N)/0.01N)
.EXTRACT FILE=Power label = pow1656 (1.2*integ(I(v0),16.65N,16.66N)/0.01N)
.EXTRACT FILE=Power label = pow1657 (1.2*integ(I(v0),16.66N,16.67N)/0.01N)
.EXTRACT FILE=Power label = pow1658 (1.2*integ(I(v0),16.67N,16.68N)/0.01N)
.EXTRACT FILE=Power label = pow1659 (1.2*integ(I(v0),16.68N,16.69N)/0.01N)
.EXTRACT FILE=Power label = pow1660 (1.2*integ(I(v0),16.69N,16.7N)/0.01N)
.EXTRACT FILE=Power label = pow1661 (1.2*integ(I(v0),16.7N,16.71N)/0.01N)
.EXTRACT FILE=Power label = pow1662 (1.2*integ(I(v0),16.71N,16.72N)/0.01N)
.EXTRACT FILE=Power label = pow1663 (1.2*integ(I(v0),16.72N,16.73N)/0.01N)
.EXTRACT FILE=Power label = pow1664 (1.2*integ(I(v0),16.73N,16.74N)/0.01N)
.EXTRACT FILE=Power label = pow1665 (1.2*integ(I(v0),16.74N,16.75N)/0.01N)
.EXTRACT FILE=Power label = pow1666 (1.2*integ(I(v0),16.75N,16.76N)/0.01N)
.EXTRACT FILE=Power label = pow1667 (1.2*integ(I(v0),16.76N,16.77N)/0.01N)
.EXTRACT FILE=Power label = pow1668 (1.2*integ(I(v0),16.77N,16.78N)/0.01N)
.EXTRACT FILE=Power label = pow1669 (1.2*integ(I(v0),16.78N,16.79N)/0.01N)
.EXTRACT FILE=Power label = pow1670 (1.2*integ(I(v0),16.79N,16.8N)/0.01N)
.EXTRACT FILE=Power label = pow1671 (1.2*integ(I(v0),16.8N,16.81N)/0.01N)
.EXTRACT FILE=Power label = pow1672 (1.2*integ(I(v0),16.81N,16.82N)/0.01N)
.EXTRACT FILE=Power label = pow1673 (1.2*integ(I(v0),16.82N,16.83N)/0.01N)
.EXTRACT FILE=Power label = pow1674 (1.2*integ(I(v0),16.83N,16.84N)/0.01N)
.EXTRACT FILE=Power label = pow1675 (1.2*integ(I(v0),16.84N,16.85N)/0.01N)
.EXTRACT FILE=Power label = pow1676 (1.2*integ(I(v0),16.85N,16.86N)/0.01N)
.EXTRACT FILE=Power label = pow1677 (1.2*integ(I(v0),16.86N,16.87N)/0.01N)
.EXTRACT FILE=Power label = pow1678 (1.2*integ(I(v0),16.87N,16.88N)/0.01N)
.EXTRACT FILE=Power label = pow1679 (1.2*integ(I(v0),16.88N,16.89N)/0.01N)
.EXTRACT FILE=Power label = pow1680 (1.2*integ(I(v0),16.89N,16.9N)/0.01N)
.EXTRACT FILE=Power label = pow1681 (1.2*integ(I(v0),16.9N,16.91N)/0.01N)
.EXTRACT FILE=Power label = pow1682 (1.2*integ(I(v0),16.91N,16.92N)/0.01N)
.EXTRACT FILE=Power label = pow1683 (1.2*integ(I(v0),16.92N,16.93N)/0.01N)
.EXTRACT FILE=Power label = pow1684 (1.2*integ(I(v0),16.93N,16.94N)/0.01N)
.EXTRACT FILE=Power label = pow1685 (1.2*integ(I(v0),16.94N,16.95N)/0.01N)
.EXTRACT FILE=Power label = pow1686 (1.2*integ(I(v0),16.95N,16.96N)/0.01N)
.EXTRACT FILE=Power label = pow1687 (1.2*integ(I(v0),16.96N,16.97N)/0.01N)
.EXTRACT FILE=Power label = pow1688 (1.2*integ(I(v0),16.97N,16.98N)/0.01N)
.EXTRACT FILE=Power label = pow1689 (1.2*integ(I(v0),16.98N,16.99N)/0.01N)
.EXTRACT FILE=Power label = pow1690 (1.2*integ(I(v0),16.99N,17.0N)/0.01N)
.EXTRACT FILE=Power label = pow1691 (1.2*integ(I(v0),17.0N,17.01N)/0.01N)
.EXTRACT FILE=Power label = pow1692 (1.2*integ(I(v0),17.01N,17.02N)/0.01N)
.EXTRACT FILE=Power label = pow1693 (1.2*integ(I(v0),17.02N,17.03N)/0.01N)
.EXTRACT FILE=Power label = pow1694 (1.2*integ(I(v0),17.03N,17.04N)/0.01N)
.EXTRACT FILE=Power label = pow1695 (1.2*integ(I(v0),17.04N,17.05N)/0.01N)
.EXTRACT FILE=Power label = pow1696 (1.2*integ(I(v0),17.05N,17.06N)/0.01N)
.EXTRACT FILE=Power label = pow1697 (1.2*integ(I(v0),17.06N,17.07N)/0.01N)
.EXTRACT FILE=Power label = pow1698 (1.2*integ(I(v0),17.07N,17.08N)/0.01N)
.EXTRACT FILE=Power label = pow1699 (1.2*integ(I(v0),17.08N,17.09N)/0.01N)
.EXTRACT FILE=Power label = pow1700 (1.2*integ(I(v0),17.09N,17.1N)/0.01N)
.EXTRACT FILE=Power label = pow1701 (1.2*integ(I(v0),17.1N,17.11N)/0.01N)
.EXTRACT FILE=Power label = pow1702 (1.2*integ(I(v0),17.11N,17.12N)/0.01N)
.EXTRACT FILE=Power label = pow1703 (1.2*integ(I(v0),17.12N,17.13N)/0.01N)
.EXTRACT FILE=Power label = pow1704 (1.2*integ(I(v0),17.13N,17.14N)/0.01N)
.EXTRACT FILE=Power label = pow1705 (1.2*integ(I(v0),17.14N,17.15N)/0.01N)
.EXTRACT FILE=Power label = pow1706 (1.2*integ(I(v0),17.15N,17.16N)/0.01N)
.EXTRACT FILE=Power label = pow1707 (1.2*integ(I(v0),17.16N,17.17N)/0.01N)
.EXTRACT FILE=Power label = pow1708 (1.2*integ(I(v0),17.17N,17.18N)/0.01N)
.EXTRACT FILE=Power label = pow1709 (1.2*integ(I(v0),17.18N,17.19N)/0.01N)
.EXTRACT FILE=Power label = pow1710 (1.2*integ(I(v0),17.19N,17.2N)/0.01N)
.EXTRACT FILE=Power label = pow1711 (1.2*integ(I(v0),17.2N,17.21N)/0.01N)
.EXTRACT FILE=Power label = pow1712 (1.2*integ(I(v0),17.21N,17.22N)/0.01N)
.EXTRACT FILE=Power label = pow1713 (1.2*integ(I(v0),17.22N,17.23N)/0.01N)
.EXTRACT FILE=Power label = pow1714 (1.2*integ(I(v0),17.23N,17.24N)/0.01N)
.EXTRACT FILE=Power label = pow1715 (1.2*integ(I(v0),17.24N,17.25N)/0.01N)
.EXTRACT FILE=Power label = pow1716 (1.2*integ(I(v0),17.25N,17.26N)/0.01N)
.EXTRACT FILE=Power label = pow1717 (1.2*integ(I(v0),17.26N,17.27N)/0.01N)
.EXTRACT FILE=Power label = pow1718 (1.2*integ(I(v0),17.27N,17.28N)/0.01N)
.EXTRACT FILE=Power label = pow1719 (1.2*integ(I(v0),17.28N,17.29N)/0.01N)
.EXTRACT FILE=Power label = pow1720 (1.2*integ(I(v0),17.29N,17.3N)/0.01N)
.EXTRACT FILE=Power label = pow1721 (1.2*integ(I(v0),17.3N,17.31N)/0.01N)
.EXTRACT FILE=Power label = pow1722 (1.2*integ(I(v0),17.31N,17.32N)/0.01N)
.EXTRACT FILE=Power label = pow1723 (1.2*integ(I(v0),17.32N,17.33N)/0.01N)
.EXTRACT FILE=Power label = pow1724 (1.2*integ(I(v0),17.33N,17.34N)/0.01N)
.EXTRACT FILE=Power label = pow1725 (1.2*integ(I(v0),17.34N,17.35N)/0.01N)
.EXTRACT FILE=Power label = pow1726 (1.2*integ(I(v0),17.35N,17.36N)/0.01N)
.EXTRACT FILE=Power label = pow1727 (1.2*integ(I(v0),17.36N,17.37N)/0.01N)
.EXTRACT FILE=Power label = pow1728 (1.2*integ(I(v0),17.37N,17.38N)/0.01N)
.EXTRACT FILE=Power label = pow1729 (1.2*integ(I(v0),17.38N,17.39N)/0.01N)
.EXTRACT FILE=Power label = pow1730 (1.2*integ(I(v0),17.39N,17.4N)/0.01N)
.EXTRACT FILE=Power label = pow1731 (1.2*integ(I(v0),17.4N,17.41N)/0.01N)
.EXTRACT FILE=Power label = pow1732 (1.2*integ(I(v0),17.41N,17.42N)/0.01N)
.EXTRACT FILE=Power label = pow1733 (1.2*integ(I(v0),17.42N,17.43N)/0.01N)
.EXTRACT FILE=Power label = pow1734 (1.2*integ(I(v0),17.43N,17.44N)/0.01N)
.EXTRACT FILE=Power label = pow1735 (1.2*integ(I(v0),17.44N,17.45N)/0.01N)
.EXTRACT FILE=Power label = pow1736 (1.2*integ(I(v0),17.45N,17.46N)/0.01N)
.EXTRACT FILE=Power label = pow1737 (1.2*integ(I(v0),17.46N,17.47N)/0.01N)
.EXTRACT FILE=Power label = pow1738 (1.2*integ(I(v0),17.47N,17.48N)/0.01N)
.EXTRACT FILE=Power label = pow1739 (1.2*integ(I(v0),17.48N,17.49N)/0.01N)
.EXTRACT FILE=Power label = pow1740 (1.2*integ(I(v0),17.49N,17.5N)/0.01N)
.EXTRACT FILE=Power label = pow1741 (1.2*integ(I(v0),17.5N,17.51N)/0.01N)
.EXTRACT FILE=Power label = pow1742 (1.2*integ(I(v0),17.51N,17.52N)/0.01N)
.EXTRACT FILE=Power label = pow1743 (1.2*integ(I(v0),17.52N,17.53N)/0.01N)
.EXTRACT FILE=Power label = pow1744 (1.2*integ(I(v0),17.53N,17.54N)/0.01N)
.EXTRACT FILE=Power label = pow1745 (1.2*integ(I(v0),17.54N,17.55N)/0.01N)
.EXTRACT FILE=Power label = pow1746 (1.2*integ(I(v0),17.55N,17.56N)/0.01N)
.EXTRACT FILE=Power label = pow1747 (1.2*integ(I(v0),17.56N,17.57N)/0.01N)
.EXTRACT FILE=Power label = pow1748 (1.2*integ(I(v0),17.57N,17.58N)/0.01N)
.EXTRACT FILE=Power label = pow1749 (1.2*integ(I(v0),17.58N,17.59N)/0.01N)
.EXTRACT FILE=Power label = pow1750 (1.2*integ(I(v0),17.59N,17.6N)/0.01N)
.EXTRACT FILE=Power label = pow1751 (1.2*integ(I(v0),17.6N,17.61N)/0.01N)
.EXTRACT FILE=Power label = pow1752 (1.2*integ(I(v0),17.61N,17.62N)/0.01N)
.EXTRACT FILE=Power label = pow1753 (1.2*integ(I(v0),17.62N,17.63N)/0.01N)
.EXTRACT FILE=Power label = pow1754 (1.2*integ(I(v0),17.63N,17.64N)/0.01N)
.EXTRACT FILE=Power label = pow1755 (1.2*integ(I(v0),17.64N,17.65N)/0.01N)
.EXTRACT FILE=Power label = pow1756 (1.2*integ(I(v0),17.65N,17.66N)/0.01N)
.EXTRACT FILE=Power label = pow1757 (1.2*integ(I(v0),17.66N,17.67N)/0.01N)
.EXTRACT FILE=Power label = pow1758 (1.2*integ(I(v0),17.67N,17.68N)/0.01N)
.EXTRACT FILE=Power label = pow1759 (1.2*integ(I(v0),17.68N,17.69N)/0.01N)
.EXTRACT FILE=Power label = pow1760 (1.2*integ(I(v0),17.69N,17.7N)/0.01N)
.EXTRACT FILE=Power label = pow1761 (1.2*integ(I(v0),17.7N,17.71N)/0.01N)
.EXTRACT FILE=Power label = pow1762 (1.2*integ(I(v0),17.71N,17.72N)/0.01N)
.EXTRACT FILE=Power label = pow1763 (1.2*integ(I(v0),17.72N,17.73N)/0.01N)
.EXTRACT FILE=Power label = pow1764 (1.2*integ(I(v0),17.73N,17.74N)/0.01N)
.EXTRACT FILE=Power label = pow1765 (1.2*integ(I(v0),17.74N,17.75N)/0.01N)
.EXTRACT FILE=Power label = pow1766 (1.2*integ(I(v0),17.75N,17.76N)/0.01N)
.EXTRACT FILE=Power label = pow1767 (1.2*integ(I(v0),17.76N,17.77N)/0.01N)
.EXTRACT FILE=Power label = pow1768 (1.2*integ(I(v0),17.77N,17.78N)/0.01N)
.EXTRACT FILE=Power label = pow1769 (1.2*integ(I(v0),17.78N,17.79N)/0.01N)
.EXTRACT FILE=Power label = pow1770 (1.2*integ(I(v0),17.79N,17.8N)/0.01N)
.EXTRACT FILE=Power label = pow1771 (1.2*integ(I(v0),17.8N,17.81N)/0.01N)
.EXTRACT FILE=Power label = pow1772 (1.2*integ(I(v0),17.81N,17.82N)/0.01N)
.EXTRACT FILE=Power label = pow1773 (1.2*integ(I(v0),17.82N,17.83N)/0.01N)
.EXTRACT FILE=Power label = pow1774 (1.2*integ(I(v0),17.83N,17.84N)/0.01N)
.EXTRACT FILE=Power label = pow1775 (1.2*integ(I(v0),17.84N,17.85N)/0.01N)
.EXTRACT FILE=Power label = pow1776 (1.2*integ(I(v0),17.85N,17.86N)/0.01N)
.EXTRACT FILE=Power label = pow1777 (1.2*integ(I(v0),17.86N,17.87N)/0.01N)
.EXTRACT FILE=Power label = pow1778 (1.2*integ(I(v0),17.87N,17.88N)/0.01N)
.EXTRACT FILE=Power label = pow1779 (1.2*integ(I(v0),17.88N,17.89N)/0.01N)
.EXTRACT FILE=Power label = pow1780 (1.2*integ(I(v0),17.89N,17.9N)/0.01N)
.EXTRACT FILE=Power label = pow1781 (1.2*integ(I(v0),17.9N,17.91N)/0.01N)
.EXTRACT FILE=Power label = pow1782 (1.2*integ(I(v0),17.91N,17.92N)/0.01N)
.EXTRACT FILE=Power label = pow1783 (1.2*integ(I(v0),17.92N,17.93N)/0.01N)
.EXTRACT FILE=Power label = pow1784 (1.2*integ(I(v0),17.93N,17.94N)/0.01N)
.EXTRACT FILE=Power label = pow1785 (1.2*integ(I(v0),17.94N,17.95N)/0.01N)
.EXTRACT FILE=Power label = pow1786 (1.2*integ(I(v0),17.95N,17.96N)/0.01N)
.EXTRACT FILE=Power label = pow1787 (1.2*integ(I(v0),17.96N,17.97N)/0.01N)
.EXTRACT FILE=Power label = pow1788 (1.2*integ(I(v0),17.97N,17.98N)/0.01N)
.EXTRACT FILE=Power label = pow1789 (1.2*integ(I(v0),17.98N,17.99N)/0.01N)
.EXTRACT FILE=Power label = pow1790 (1.2*integ(I(v0),17.99N,18.0N)/0.01N)
.EXTRACT FILE=Power label = pow1791 (1.2*integ(I(v0),18.0N,18.01N)/0.01N)
.EXTRACT FILE=Power label = pow1792 (1.2*integ(I(v0),18.01N,18.02N)/0.01N)
.EXTRACT FILE=Power label = pow1793 (1.2*integ(I(v0),18.02N,18.03N)/0.01N)
.EXTRACT FILE=Power label = pow1794 (1.2*integ(I(v0),18.03N,18.04N)/0.01N)
.EXTRACT FILE=Power label = pow1795 (1.2*integ(I(v0),18.04N,18.05N)/0.01N)
.EXTRACT FILE=Power label = pow1796 (1.2*integ(I(v0),18.05N,18.06N)/0.01N)
.EXTRACT FILE=Power label = pow1797 (1.2*integ(I(v0),18.06N,18.07N)/0.01N)
.EXTRACT FILE=Power label = pow1798 (1.2*integ(I(v0),18.07N,18.08N)/0.01N)
.EXTRACT FILE=Power label = pow1799 (1.2*integ(I(v0),18.08N,18.09N)/0.01N)
.EXTRACT FILE=Power label = pow1800 (1.2*integ(I(v0),18.09N,18.1N)/0.01N)
.EXTRACT FILE=Power label = pow1801 (1.2*integ(I(v0),18.1N,18.11N)/0.01N)
.EXTRACT FILE=Power label = pow1802 (1.2*integ(I(v0),18.11N,18.12N)/0.01N)
.EXTRACT FILE=Power label = pow1803 (1.2*integ(I(v0),18.12N,18.13N)/0.01N)
.EXTRACT FILE=Power label = pow1804 (1.2*integ(I(v0),18.13N,18.14N)/0.01N)
.EXTRACT FILE=Power label = pow1805 (1.2*integ(I(v0),18.14N,18.15N)/0.01N)
.EXTRACT FILE=Power label = pow1806 (1.2*integ(I(v0),18.15N,18.16N)/0.01N)
.EXTRACT FILE=Power label = pow1807 (1.2*integ(I(v0),18.16N,18.17N)/0.01N)
.EXTRACT FILE=Power label = pow1808 (1.2*integ(I(v0),18.17N,18.18N)/0.01N)
.EXTRACT FILE=Power label = pow1809 (1.2*integ(I(v0),18.18N,18.19N)/0.01N)
.EXTRACT FILE=Power label = pow1810 (1.2*integ(I(v0),18.19N,18.2N)/0.01N)
.EXTRACT FILE=Power label = pow1811 (1.2*integ(I(v0),18.2N,18.21N)/0.01N)
.EXTRACT FILE=Power label = pow1812 (1.2*integ(I(v0),18.21N,18.22N)/0.01N)
.EXTRACT FILE=Power label = pow1813 (1.2*integ(I(v0),18.22N,18.23N)/0.01N)
.EXTRACT FILE=Power label = pow1814 (1.2*integ(I(v0),18.23N,18.24N)/0.01N)
.EXTRACT FILE=Power label = pow1815 (1.2*integ(I(v0),18.24N,18.25N)/0.01N)
.EXTRACT FILE=Power label = pow1816 (1.2*integ(I(v0),18.25N,18.26N)/0.01N)
.EXTRACT FILE=Power label = pow1817 (1.2*integ(I(v0),18.26N,18.27N)/0.01N)
.EXTRACT FILE=Power label = pow1818 (1.2*integ(I(v0),18.27N,18.28N)/0.01N)
.EXTRACT FILE=Power label = pow1819 (1.2*integ(I(v0),18.28N,18.29N)/0.01N)
.EXTRACT FILE=Power label = pow1820 (1.2*integ(I(v0),18.29N,18.3N)/0.01N)
.EXTRACT FILE=Power label = pow1821 (1.2*integ(I(v0),18.3N,18.31N)/0.01N)
.EXTRACT FILE=Power label = pow1822 (1.2*integ(I(v0),18.31N,18.32N)/0.01N)
.EXTRACT FILE=Power label = pow1823 (1.2*integ(I(v0),18.32N,18.33N)/0.01N)
.EXTRACT FILE=Power label = pow1824 (1.2*integ(I(v0),18.33N,18.34N)/0.01N)
.EXTRACT FILE=Power label = pow1825 (1.2*integ(I(v0),18.34N,18.35N)/0.01N)
.EXTRACT FILE=Power label = pow1826 (1.2*integ(I(v0),18.35N,18.36N)/0.01N)
.EXTRACT FILE=Power label = pow1827 (1.2*integ(I(v0),18.36N,18.37N)/0.01N)
.EXTRACT FILE=Power label = pow1828 (1.2*integ(I(v0),18.37N,18.38N)/0.01N)
.EXTRACT FILE=Power label = pow1829 (1.2*integ(I(v0),18.38N,18.39N)/0.01N)
.EXTRACT FILE=Power label = pow1830 (1.2*integ(I(v0),18.39N,18.4N)/0.01N)
.EXTRACT FILE=Power label = pow1831 (1.2*integ(I(v0),18.4N,18.41N)/0.01N)
.EXTRACT FILE=Power label = pow1832 (1.2*integ(I(v0),18.41N,18.42N)/0.01N)
.EXTRACT FILE=Power label = pow1833 (1.2*integ(I(v0),18.42N,18.43N)/0.01N)
.EXTRACT FILE=Power label = pow1834 (1.2*integ(I(v0),18.43N,18.44N)/0.01N)
.EXTRACT FILE=Power label = pow1835 (1.2*integ(I(v0),18.44N,18.45N)/0.01N)
.EXTRACT FILE=Power label = pow1836 (1.2*integ(I(v0),18.45N,18.46N)/0.01N)
.EXTRACT FILE=Power label = pow1837 (1.2*integ(I(v0),18.46N,18.47N)/0.01N)
.EXTRACT FILE=Power label = pow1838 (1.2*integ(I(v0),18.47N,18.48N)/0.01N)
.EXTRACT FILE=Power label = pow1839 (1.2*integ(I(v0),18.48N,18.49N)/0.01N)
.EXTRACT FILE=Power label = pow1840 (1.2*integ(I(v0),18.49N,18.5N)/0.01N)
.EXTRACT FILE=Power label = pow1841 (1.2*integ(I(v0),18.5N,18.51N)/0.01N)
.EXTRACT FILE=Power label = pow1842 (1.2*integ(I(v0),18.51N,18.52N)/0.01N)
.EXTRACT FILE=Power label = pow1843 (1.2*integ(I(v0),18.52N,18.53N)/0.01N)
.EXTRACT FILE=Power label = pow1844 (1.2*integ(I(v0),18.53N,18.54N)/0.01N)
.EXTRACT FILE=Power label = pow1845 (1.2*integ(I(v0),18.54N,18.55N)/0.01N)
.EXTRACT FILE=Power label = pow1846 (1.2*integ(I(v0),18.55N,18.56N)/0.01N)
.EXTRACT FILE=Power label = pow1847 (1.2*integ(I(v0),18.56N,18.57N)/0.01N)
.EXTRACT FILE=Power label = pow1848 (1.2*integ(I(v0),18.57N,18.58N)/0.01N)
.EXTRACT FILE=Power label = pow1849 (1.2*integ(I(v0),18.58N,18.59N)/0.01N)
.EXTRACT FILE=Power label = pow1850 (1.2*integ(I(v0),18.59N,18.6N)/0.01N)
.EXTRACT FILE=Power label = pow1851 (1.2*integ(I(v0),18.6N,18.61N)/0.01N)
.EXTRACT FILE=Power label = pow1852 (1.2*integ(I(v0),18.61N,18.62N)/0.01N)
.EXTRACT FILE=Power label = pow1853 (1.2*integ(I(v0),18.62N,18.63N)/0.01N)
.EXTRACT FILE=Power label = pow1854 (1.2*integ(I(v0),18.63N,18.64N)/0.01N)
.EXTRACT FILE=Power label = pow1855 (1.2*integ(I(v0),18.64N,18.65N)/0.01N)
.EXTRACT FILE=Power label = pow1856 (1.2*integ(I(v0),18.65N,18.66N)/0.01N)
.EXTRACT FILE=Power label = pow1857 (1.2*integ(I(v0),18.66N,18.67N)/0.01N)
.EXTRACT FILE=Power label = pow1858 (1.2*integ(I(v0),18.67N,18.68N)/0.01N)
.EXTRACT FILE=Power label = pow1859 (1.2*integ(I(v0),18.68N,18.69N)/0.01N)
.EXTRACT FILE=Power label = pow1860 (1.2*integ(I(v0),18.69N,18.7N)/0.01N)
.EXTRACT FILE=Power label = pow1861 (1.2*integ(I(v0),18.7N,18.71N)/0.01N)
.EXTRACT FILE=Power label = pow1862 (1.2*integ(I(v0),18.71N,18.72N)/0.01N)
.EXTRACT FILE=Power label = pow1863 (1.2*integ(I(v0),18.72N,18.73N)/0.01N)
.EXTRACT FILE=Power label = pow1864 (1.2*integ(I(v0),18.73N,18.74N)/0.01N)
.EXTRACT FILE=Power label = pow1865 (1.2*integ(I(v0),18.74N,18.75N)/0.01N)
.EXTRACT FILE=Power label = pow1866 (1.2*integ(I(v0),18.75N,18.76N)/0.01N)
.EXTRACT FILE=Power label = pow1867 (1.2*integ(I(v0),18.76N,18.77N)/0.01N)
.EXTRACT FILE=Power label = pow1868 (1.2*integ(I(v0),18.77N,18.78N)/0.01N)
.EXTRACT FILE=Power label = pow1869 (1.2*integ(I(v0),18.78N,18.79N)/0.01N)
.EXTRACT FILE=Power label = pow1870 (1.2*integ(I(v0),18.79N,18.8N)/0.01N)
.EXTRACT FILE=Power label = pow1871 (1.2*integ(I(v0),18.8N,18.81N)/0.01N)
.EXTRACT FILE=Power label = pow1872 (1.2*integ(I(v0),18.81N,18.82N)/0.01N)
.EXTRACT FILE=Power label = pow1873 (1.2*integ(I(v0),18.82N,18.83N)/0.01N)
.EXTRACT FILE=Power label = pow1874 (1.2*integ(I(v0),18.83N,18.84N)/0.01N)
.EXTRACT FILE=Power label = pow1875 (1.2*integ(I(v0),18.84N,18.85N)/0.01N)
.EXTRACT FILE=Power label = pow1876 (1.2*integ(I(v0),18.85N,18.86N)/0.01N)
.EXTRACT FILE=Power label = pow1877 (1.2*integ(I(v0),18.86N,18.87N)/0.01N)
.EXTRACT FILE=Power label = pow1878 (1.2*integ(I(v0),18.87N,18.88N)/0.01N)
.EXTRACT FILE=Power label = pow1879 (1.2*integ(I(v0),18.88N,18.89N)/0.01N)
.EXTRACT FILE=Power label = pow1880 (1.2*integ(I(v0),18.89N,18.9N)/0.01N)
.EXTRACT FILE=Power label = pow1881 (1.2*integ(I(v0),18.9N,18.91N)/0.01N)
.EXTRACT FILE=Power label = pow1882 (1.2*integ(I(v0),18.91N,18.92N)/0.01N)
.EXTRACT FILE=Power label = pow1883 (1.2*integ(I(v0),18.92N,18.93N)/0.01N)
.EXTRACT FILE=Power label = pow1884 (1.2*integ(I(v0),18.93N,18.94N)/0.01N)
.EXTRACT FILE=Power label = pow1885 (1.2*integ(I(v0),18.94N,18.95N)/0.01N)
.EXTRACT FILE=Power label = pow1886 (1.2*integ(I(v0),18.95N,18.96N)/0.01N)
.EXTRACT FILE=Power label = pow1887 (1.2*integ(I(v0),18.96N,18.97N)/0.01N)
.EXTRACT FILE=Power label = pow1888 (1.2*integ(I(v0),18.97N,18.98N)/0.01N)
.EXTRACT FILE=Power label = pow1889 (1.2*integ(I(v0),18.98N,18.99N)/0.01N)
.EXTRACT FILE=Power label = pow1890 (1.2*integ(I(v0),18.99N,19.0N)/0.01N)
.EXTRACT FILE=Power label = pow1891 (1.2*integ(I(v0),19.0N,19.01N)/0.01N)
.EXTRACT FILE=Power label = pow1892 (1.2*integ(I(v0),19.01N,19.02N)/0.01N)
.EXTRACT FILE=Power label = pow1893 (1.2*integ(I(v0),19.02N,19.03N)/0.01N)
.EXTRACT FILE=Power label = pow1894 (1.2*integ(I(v0),19.03N,19.04N)/0.01N)
.EXTRACT FILE=Power label = pow1895 (1.2*integ(I(v0),19.04N,19.05N)/0.01N)
.EXTRACT FILE=Power label = pow1896 (1.2*integ(I(v0),19.05N,19.06N)/0.01N)
.EXTRACT FILE=Power label = pow1897 (1.2*integ(I(v0),19.06N,19.07N)/0.01N)
.EXTRACT FILE=Power label = pow1898 (1.2*integ(I(v0),19.07N,19.08N)/0.01N)
.EXTRACT FILE=Power label = pow1899 (1.2*integ(I(v0),19.08N,19.09N)/0.01N)
.EXTRACT FILE=Power label = pow1900 (1.2*integ(I(v0),19.09N,19.1N)/0.01N)
.EXTRACT FILE=Power label = pow1901 (1.2*integ(I(v0),19.1N,19.11N)/0.01N)
.EXTRACT FILE=Power label = pow1902 (1.2*integ(I(v0),19.11N,19.12N)/0.01N)
.EXTRACT FILE=Power label = pow1903 (1.2*integ(I(v0),19.12N,19.13N)/0.01N)
.EXTRACT FILE=Power label = pow1904 (1.2*integ(I(v0),19.13N,19.14N)/0.01N)
.EXTRACT FILE=Power label = pow1905 (1.2*integ(I(v0),19.14N,19.15N)/0.01N)
.EXTRACT FILE=Power label = pow1906 (1.2*integ(I(v0),19.15N,19.16N)/0.01N)
.EXTRACT FILE=Power label = pow1907 (1.2*integ(I(v0),19.16N,19.17N)/0.01N)
.EXTRACT FILE=Power label = pow1908 (1.2*integ(I(v0),19.17N,19.18N)/0.01N)
.EXTRACT FILE=Power label = pow1909 (1.2*integ(I(v0),19.18N,19.19N)/0.01N)
.EXTRACT FILE=Power label = pow1910 (1.2*integ(I(v0),19.19N,19.2N)/0.01N)
.EXTRACT FILE=Power label = pow1911 (1.2*integ(I(v0),19.2N,19.21N)/0.01N)
.EXTRACT FILE=Power label = pow1912 (1.2*integ(I(v0),19.21N,19.22N)/0.01N)
.EXTRACT FILE=Power label = pow1913 (1.2*integ(I(v0),19.22N,19.23N)/0.01N)
.EXTRACT FILE=Power label = pow1914 (1.2*integ(I(v0),19.23N,19.24N)/0.01N)
.EXTRACT FILE=Power label = pow1915 (1.2*integ(I(v0),19.24N,19.25N)/0.01N)
.EXTRACT FILE=Power label = pow1916 (1.2*integ(I(v0),19.25N,19.26N)/0.01N)
.EXTRACT FILE=Power label = pow1917 (1.2*integ(I(v0),19.26N,19.27N)/0.01N)
.EXTRACT FILE=Power label = pow1918 (1.2*integ(I(v0),19.27N,19.28N)/0.01N)
.EXTRACT FILE=Power label = pow1919 (1.2*integ(I(v0),19.28N,19.29N)/0.01N)
.EXTRACT FILE=Power label = pow1920 (1.2*integ(I(v0),19.29N,19.3N)/0.01N)
.EXTRACT FILE=Power label = pow1921 (1.2*integ(I(v0),19.3N,19.31N)/0.01N)
.EXTRACT FILE=Power label = pow1922 (1.2*integ(I(v0),19.31N,19.32N)/0.01N)
.EXTRACT FILE=Power label = pow1923 (1.2*integ(I(v0),19.32N,19.33N)/0.01N)
.EXTRACT FILE=Power label = pow1924 (1.2*integ(I(v0),19.33N,19.34N)/0.01N)
.EXTRACT FILE=Power label = pow1925 (1.2*integ(I(v0),19.34N,19.35N)/0.01N)
.EXTRACT FILE=Power label = pow1926 (1.2*integ(I(v0),19.35N,19.36N)/0.01N)
.EXTRACT FILE=Power label = pow1927 (1.2*integ(I(v0),19.36N,19.37N)/0.01N)
.EXTRACT FILE=Power label = pow1928 (1.2*integ(I(v0),19.37N,19.38N)/0.01N)
.EXTRACT FILE=Power label = pow1929 (1.2*integ(I(v0),19.38N,19.39N)/0.01N)
.EXTRACT FILE=Power label = pow1930 (1.2*integ(I(v0),19.39N,19.4N)/0.01N)
.EXTRACT FILE=Power label = pow1931 (1.2*integ(I(v0),19.4N,19.41N)/0.01N)
.EXTRACT FILE=Power label = pow1932 (1.2*integ(I(v0),19.41N,19.42N)/0.01N)
.EXTRACT FILE=Power label = pow1933 (1.2*integ(I(v0),19.42N,19.43N)/0.01N)
.EXTRACT FILE=Power label = pow1934 (1.2*integ(I(v0),19.43N,19.44N)/0.01N)
.EXTRACT FILE=Power label = pow1935 (1.2*integ(I(v0),19.44N,19.45N)/0.01N)
.EXTRACT FILE=Power label = pow1936 (1.2*integ(I(v0),19.45N,19.46N)/0.01N)
.EXTRACT FILE=Power label = pow1937 (1.2*integ(I(v0),19.46N,19.47N)/0.01N)
.EXTRACT FILE=Power label = pow1938 (1.2*integ(I(v0),19.47N,19.48N)/0.01N)
.EXTRACT FILE=Power label = pow1939 (1.2*integ(I(v0),19.48N,19.49N)/0.01N)
.EXTRACT FILE=Power label = pow1940 (1.2*integ(I(v0),19.49N,19.5N)/0.01N)
.EXTRACT FILE=Power label = pow1941 (1.2*integ(I(v0),19.5N,19.51N)/0.01N)
.EXTRACT FILE=Power label = pow1942 (1.2*integ(I(v0),19.51N,19.52N)/0.01N)
.EXTRACT FILE=Power label = pow1943 (1.2*integ(I(v0),19.52N,19.53N)/0.01N)
.EXTRACT FILE=Power label = pow1944 (1.2*integ(I(v0),19.53N,19.54N)/0.01N)
.EXTRACT FILE=Power label = pow1945 (1.2*integ(I(v0),19.54N,19.55N)/0.01N)
.EXTRACT FILE=Power label = pow1946 (1.2*integ(I(v0),19.55N,19.56N)/0.01N)
.EXTRACT FILE=Power label = pow1947 (1.2*integ(I(v0),19.56N,19.57N)/0.01N)
.EXTRACT FILE=Power label = pow1948 (1.2*integ(I(v0),19.57N,19.58N)/0.01N)
.EXTRACT FILE=Power label = pow1949 (1.2*integ(I(v0),19.58N,19.59N)/0.01N)
.EXTRACT FILE=Power label = pow1950 (1.2*integ(I(v0),19.59N,19.6N)/0.01N)
.EXTRACT FILE=Power label = pow1951 (1.2*integ(I(v0),19.6N,19.61N)/0.01N)
.EXTRACT FILE=Power label = pow1952 (1.2*integ(I(v0),19.61N,19.62N)/0.01N)
.EXTRACT FILE=Power label = pow1953 (1.2*integ(I(v0),19.62N,19.63N)/0.01N)
.EXTRACT FILE=Power label = pow1954 (1.2*integ(I(v0),19.63N,19.64N)/0.01N)
.EXTRACT FILE=Power label = pow1955 (1.2*integ(I(v0),19.64N,19.65N)/0.01N)
.EXTRACT FILE=Power label = pow1956 (1.2*integ(I(v0),19.65N,19.66N)/0.01N)
.EXTRACT FILE=Power label = pow1957 (1.2*integ(I(v0),19.66N,19.67N)/0.01N)
.EXTRACT FILE=Power label = pow1958 (1.2*integ(I(v0),19.67N,19.68N)/0.01N)
.EXTRACT FILE=Power label = pow1959 (1.2*integ(I(v0),19.68N,19.69N)/0.01N)
.EXTRACT FILE=Power label = pow1960 (1.2*integ(I(v0),19.69N,19.7N)/0.01N)
.EXTRACT FILE=Power label = pow1961 (1.2*integ(I(v0),19.7N,19.71N)/0.01N)
.EXTRACT FILE=Power label = pow1962 (1.2*integ(I(v0),19.71N,19.72N)/0.01N)
.EXTRACT FILE=Power label = pow1963 (1.2*integ(I(v0),19.72N,19.73N)/0.01N)
.EXTRACT FILE=Power label = pow1964 (1.2*integ(I(v0),19.73N,19.74N)/0.01N)
.EXTRACT FILE=Power label = pow1965 (1.2*integ(I(v0),19.74N,19.75N)/0.01N)
.EXTRACT FILE=Power label = pow1966 (1.2*integ(I(v0),19.75N,19.76N)/0.01N)
.EXTRACT FILE=Power label = pow1967 (1.2*integ(I(v0),19.76N,19.77N)/0.01N)
.EXTRACT FILE=Power label = pow1968 (1.2*integ(I(v0),19.77N,19.78N)/0.01N)
.EXTRACT FILE=Power label = pow1969 (1.2*integ(I(v0),19.78N,19.79N)/0.01N)
.EXTRACT FILE=Power label = pow1970 (1.2*integ(I(v0),19.79N,19.8N)/0.01N)
.EXTRACT FILE=Power label = pow1971 (1.2*integ(I(v0),19.8N,19.81N)/0.01N)
.EXTRACT FILE=Power label = pow1972 (1.2*integ(I(v0),19.81N,19.82N)/0.01N)
.EXTRACT FILE=Power label = pow1973 (1.2*integ(I(v0),19.82N,19.83N)/0.01N)
.EXTRACT FILE=Power label = pow1974 (1.2*integ(I(v0),19.83N,19.84N)/0.01N)
.EXTRACT FILE=Power label = pow1975 (1.2*integ(I(v0),19.84N,19.85N)/0.01N)
.EXTRACT FILE=Power label = pow1976 (1.2*integ(I(v0),19.85N,19.86N)/0.01N)
.EXTRACT FILE=Power label = pow1977 (1.2*integ(I(v0),19.86N,19.87N)/0.01N)
.EXTRACT FILE=Power label = pow1978 (1.2*integ(I(v0),19.87N,19.88N)/0.01N)
.EXTRACT FILE=Power label = pow1979 (1.2*integ(I(v0),19.88N,19.89N)/0.01N)
.EXTRACT FILE=Power label = pow1980 (1.2*integ(I(v0),19.89N,19.9N)/0.01N)
.EXTRACT FILE=Power label = pow1981 (1.2*integ(I(v0),19.9N,19.91N)/0.01N)
.EXTRACT FILE=Power label = pow1982 (1.2*integ(I(v0),19.91N,19.92N)/0.01N)
.EXTRACT FILE=Power label = pow1983 (1.2*integ(I(v0),19.92N,19.93N)/0.01N)
.EXTRACT FILE=Power label = pow1984 (1.2*integ(I(v0),19.93N,19.94N)/0.01N)
.EXTRACT FILE=Power label = pow1985 (1.2*integ(I(v0),19.94N,19.95N)/0.01N)
.EXTRACT FILE=Power label = pow1986 (1.2*integ(I(v0),19.95N,19.96N)/0.01N)
.EXTRACT FILE=Power label = pow1987 (1.2*integ(I(v0),19.96N,19.97N)/0.01N)
.EXTRACT FILE=Power label = pow1988 (1.2*integ(I(v0),19.97N,19.98N)/0.01N)
.EXTRACT FILE=Power label = pow1989 (1.2*integ(I(v0),19.98N,19.99N)/0.01N)
.EXTRACT FILE=Power label = pow1990 (1.2*integ(I(v0),19.99N,20.0N)/0.01N)
.EXTRACT FILE=Power label = pow1991 (1.2*integ(I(v0),20.0N,20.01N)/0.01N)
.EXTRACT FILE=Power label = pow1992 (1.2*integ(I(v0),20.01N,20.02N)/0.01N)
.EXTRACT FILE=Power label = pow1993 (1.2*integ(I(v0),20.02N,20.03N)/0.01N)
.EXTRACT FILE=Power label = pow1994 (1.2*integ(I(v0),20.03N,20.04N)/0.01N)
.EXTRACT FILE=Power label = pow1995 (1.2*integ(I(v0),20.04N,20.05N)/0.01N)
.EXTRACT FILE=Power label = pow1996 (1.2*integ(I(v0),20.05N,20.06N)/0.01N)
.EXTRACT FILE=Power label = pow1997 (1.2*integ(I(v0),20.06N,20.07N)/0.01N)
.EXTRACT FILE=Power label = pow1998 (1.2*integ(I(v0),20.07N,20.08N)/0.01N)
.EXTRACT FILE=Power label = pow1999 (1.2*integ(I(v0),20.08N,20.09N)/0.01N)
.EXTRACT FILE=Power label = pow2000 (1.2*integ(I(v0),20.09N,20.1N)/0.01N)
.EXTRACT FILE=Power label = pow2001 (1.2*integ(I(v0),20.1N,20.11N)/0.01N)
.EXTRACT FILE=Power label = pow2002 (1.2*integ(I(v0),20.11N,20.12N)/0.01N)
.EXTRACT FILE=Power label = pow2003 (1.2*integ(I(v0),20.12N,20.13N)/0.01N)
.EXTRACT FILE=Power label = pow2004 (1.2*integ(I(v0),20.13N,20.14N)/0.01N)
.EXTRACT FILE=Power label = pow2005 (1.2*integ(I(v0),20.14N,20.15N)/0.01N)
.EXTRACT FILE=Power label = pow2006 (1.2*integ(I(v0),20.15N,20.16N)/0.01N)
.EXTRACT FILE=Power label = pow2007 (1.2*integ(I(v0),20.16N,20.17N)/0.01N)
.EXTRACT FILE=Power label = pow2008 (1.2*integ(I(v0),20.17N,20.18N)/0.01N)
.EXTRACT FILE=Power label = pow2009 (1.2*integ(I(v0),20.18N,20.19N)/0.01N)
.EXTRACT FILE=Power label = pow2010 (1.2*integ(I(v0),20.19N,20.2N)/0.01N)
.EXTRACT FILE=Power label = pow2011 (1.2*integ(I(v0),20.2N,20.21N)/0.01N)
.EXTRACT FILE=Power label = pow2012 (1.2*integ(I(v0),20.21N,20.22N)/0.01N)
.EXTRACT FILE=Power label = pow2013 (1.2*integ(I(v0),20.22N,20.23N)/0.01N)
.EXTRACT FILE=Power label = pow2014 (1.2*integ(I(v0),20.23N,20.24N)/0.01N)
.EXTRACT FILE=Power label = pow2015 (1.2*integ(I(v0),20.24N,20.25N)/0.01N)
.EXTRACT FILE=Power label = pow2016 (1.2*integ(I(v0),20.25N,20.26N)/0.01N)
.EXTRACT FILE=Power label = pow2017 (1.2*integ(I(v0),20.26N,20.27N)/0.01N)
.EXTRACT FILE=Power label = pow2018 (1.2*integ(I(v0),20.27N,20.28N)/0.01N)
.EXTRACT FILE=Power label = pow2019 (1.2*integ(I(v0),20.28N,20.29N)/0.01N)
.EXTRACT FILE=Power label = pow2020 (1.2*integ(I(v0),20.29N,20.3N)/0.01N)
.EXTRACT FILE=Power label = pow2021 (1.2*integ(I(v0),20.3N,20.31N)/0.01N)
.EXTRACT FILE=Power label = pow2022 (1.2*integ(I(v0),20.31N,20.32N)/0.01N)
.EXTRACT FILE=Power label = pow2023 (1.2*integ(I(v0),20.32N,20.33N)/0.01N)
.EXTRACT FILE=Power label = pow2024 (1.2*integ(I(v0),20.33N,20.34N)/0.01N)
.EXTRACT FILE=Power label = pow2025 (1.2*integ(I(v0),20.34N,20.35N)/0.01N)
.EXTRACT FILE=Power label = pow2026 (1.2*integ(I(v0),20.35N,20.36N)/0.01N)
.EXTRACT FILE=Power label = pow2027 (1.2*integ(I(v0),20.36N,20.37N)/0.01N)
.EXTRACT FILE=Power label = pow2028 (1.2*integ(I(v0),20.37N,20.38N)/0.01N)
.EXTRACT FILE=Power label = pow2029 (1.2*integ(I(v0),20.38N,20.39N)/0.01N)
.EXTRACT FILE=Power label = pow2030 (1.2*integ(I(v0),20.39N,20.4N)/0.01N)
.EXTRACT FILE=Power label = pow2031 (1.2*integ(I(v0),20.4N,20.41N)/0.01N)
.EXTRACT FILE=Power label = pow2032 (1.2*integ(I(v0),20.41N,20.42N)/0.01N)
.EXTRACT FILE=Power label = pow2033 (1.2*integ(I(v0),20.42N,20.43N)/0.01N)
.EXTRACT FILE=Power label = pow2034 (1.2*integ(I(v0),20.43N,20.44N)/0.01N)
.EXTRACT FILE=Power label = pow2035 (1.2*integ(I(v0),20.44N,20.45N)/0.01N)
.EXTRACT FILE=Power label = pow2036 (1.2*integ(I(v0),20.45N,20.46N)/0.01N)
.EXTRACT FILE=Power label = pow2037 (1.2*integ(I(v0),20.46N,20.47N)/0.01N)
.EXTRACT FILE=Power label = pow2038 (1.2*integ(I(v0),20.47N,20.48N)/0.01N)
.EXTRACT FILE=Power label = pow2039 (1.2*integ(I(v0),20.48N,20.49N)/0.01N)
.EXTRACT FILE=Power label = pow2040 (1.2*integ(I(v0),20.49N,20.5N)/0.01N)
.EXTRACT FILE=Power label = pow2041 (1.2*integ(I(v0),20.5N,20.51N)/0.01N)
.EXTRACT FILE=Power label = pow2042 (1.2*integ(I(v0),20.51N,20.52N)/0.01N)
.EXTRACT FILE=Power label = pow2043 (1.2*integ(I(v0),20.52N,20.53N)/0.01N)
.EXTRACT FILE=Power label = pow2044 (1.2*integ(I(v0),20.53N,20.54N)/0.01N)
.EXTRACT FILE=Power label = pow2045 (1.2*integ(I(v0),20.54N,20.55N)/0.01N)
.EXTRACT FILE=Power label = pow2046 (1.2*integ(I(v0),20.55N,20.56N)/0.01N)
.EXTRACT FILE=Power label = pow2047 (1.2*integ(I(v0),20.56N,20.57N)/0.01N)
.EXTRACT FILE=Power label = pow2048 (1.2*integ(I(v0),20.57N,20.58N)/0.01N)
.EXTRACT FILE=Power label = pow2049 (1.2*integ(I(v0),20.58N,20.59N)/0.01N)
.EXTRACT FILE=Power label = pow2050 (1.2*integ(I(v0),20.59N,20.6N)/0.01N)
.EXTRACT FILE=Power label = pow2051 (1.2*integ(I(v0),20.6N,20.61N)/0.01N)
.EXTRACT FILE=Power label = pow2052 (1.2*integ(I(v0),20.61N,20.62N)/0.01N)
.EXTRACT FILE=Power label = pow2053 (1.2*integ(I(v0),20.62N,20.63N)/0.01N)
.EXTRACT FILE=Power label = pow2054 (1.2*integ(I(v0),20.63N,20.64N)/0.01N)
.EXTRACT FILE=Power label = pow2055 (1.2*integ(I(v0),20.64N,20.65N)/0.01N)
.EXTRACT FILE=Power label = pow2056 (1.2*integ(I(v0),20.65N,20.66N)/0.01N)
.EXTRACT FILE=Power label = pow2057 (1.2*integ(I(v0),20.66N,20.67N)/0.01N)
.EXTRACT FILE=Power label = pow2058 (1.2*integ(I(v0),20.67N,20.68N)/0.01N)
.EXTRACT FILE=Power label = pow2059 (1.2*integ(I(v0),20.68N,20.69N)/0.01N)
.EXTRACT FILE=Power label = pow2060 (1.2*integ(I(v0),20.69N,20.7N)/0.01N)
.EXTRACT FILE=Power label = pow2061 (1.2*integ(I(v0),20.7N,20.71N)/0.01N)
.EXTRACT FILE=Power label = pow2062 (1.2*integ(I(v0),20.71N,20.72N)/0.01N)
.EXTRACT FILE=Power label = pow2063 (1.2*integ(I(v0),20.72N,20.73N)/0.01N)
.EXTRACT FILE=Power label = pow2064 (1.2*integ(I(v0),20.73N,20.74N)/0.01N)
.EXTRACT FILE=Power label = pow2065 (1.2*integ(I(v0),20.74N,20.75N)/0.01N)
.EXTRACT FILE=Power label = pow2066 (1.2*integ(I(v0),20.75N,20.76N)/0.01N)
.EXTRACT FILE=Power label = pow2067 (1.2*integ(I(v0),20.76N,20.77N)/0.01N)
.EXTRACT FILE=Power label = pow2068 (1.2*integ(I(v0),20.77N,20.78N)/0.01N)
.EXTRACT FILE=Power label = pow2069 (1.2*integ(I(v0),20.78N,20.79N)/0.01N)
.EXTRACT FILE=Power label = pow2070 (1.2*integ(I(v0),20.79N,20.8N)/0.01N)
.EXTRACT FILE=Power label = pow2071 (1.2*integ(I(v0),20.8N,20.81N)/0.01N)
.EXTRACT FILE=Power label = pow2072 (1.2*integ(I(v0),20.81N,20.82N)/0.01N)
.EXTRACT FILE=Power label = pow2073 (1.2*integ(I(v0),20.82N,20.83N)/0.01N)
.EXTRACT FILE=Power label = pow2074 (1.2*integ(I(v0),20.83N,20.84N)/0.01N)
.EXTRACT FILE=Power label = pow2075 (1.2*integ(I(v0),20.84N,20.85N)/0.01N)
.EXTRACT FILE=Power label = pow2076 (1.2*integ(I(v0),20.85N,20.86N)/0.01N)
.EXTRACT FILE=Power label = pow2077 (1.2*integ(I(v0),20.86N,20.87N)/0.01N)
.EXTRACT FILE=Power label = pow2078 (1.2*integ(I(v0),20.87N,20.88N)/0.01N)
.EXTRACT FILE=Power label = pow2079 (1.2*integ(I(v0),20.88N,20.89N)/0.01N)
.EXTRACT FILE=Power label = pow2080 (1.2*integ(I(v0),20.89N,20.9N)/0.01N)
.EXTRACT FILE=Power label = pow2081 (1.2*integ(I(v0),20.9N,20.91N)/0.01N)
.EXTRACT FILE=Power label = pow2082 (1.2*integ(I(v0),20.91N,20.92N)/0.01N)
.EXTRACT FILE=Power label = pow2083 (1.2*integ(I(v0),20.92N,20.93N)/0.01N)
.EXTRACT FILE=Power label = pow2084 (1.2*integ(I(v0),20.93N,20.94N)/0.01N)
.EXTRACT FILE=Power label = pow2085 (1.2*integ(I(v0),20.94N,20.95N)/0.01N)
.EXTRACT FILE=Power label = pow2086 (1.2*integ(I(v0),20.95N,20.96N)/0.01N)
.EXTRACT FILE=Power label = pow2087 (1.2*integ(I(v0),20.96N,20.97N)/0.01N)
.EXTRACT FILE=Power label = pow2088 (1.2*integ(I(v0),20.97N,20.98N)/0.01N)
.EXTRACT FILE=Power label = pow2089 (1.2*integ(I(v0),20.98N,20.99N)/0.01N)
.EXTRACT FILE=Power label = pow2090 (1.2*integ(I(v0),20.99N,21.0N)/0.01N)
.EXTRACT FILE=Power label = pow2091 (1.2*integ(I(v0),21.0N,21.01N)/0.01N)
.EXTRACT FILE=Power label = pow2092 (1.2*integ(I(v0),21.01N,21.02N)/0.01N)
.EXTRACT FILE=Power label = pow2093 (1.2*integ(I(v0),21.02N,21.03N)/0.01N)
.EXTRACT FILE=Power label = pow2094 (1.2*integ(I(v0),21.03N,21.04N)/0.01N)
.EXTRACT FILE=Power label = pow2095 (1.2*integ(I(v0),21.04N,21.05N)/0.01N)
.EXTRACT FILE=Power label = pow2096 (1.2*integ(I(v0),21.05N,21.06N)/0.01N)
.EXTRACT FILE=Power label = pow2097 (1.2*integ(I(v0),21.06N,21.07N)/0.01N)
.EXTRACT FILE=Power label = pow2098 (1.2*integ(I(v0),21.07N,21.08N)/0.01N)
.EXTRACT FILE=Power label = pow2099 (1.2*integ(I(v0),21.08N,21.09N)/0.01N)
.EXTRACT FILE=Power label = pow2100 (1.2*integ(I(v0),21.09N,21.1N)/0.01N)
.EXTRACT FILE=Power label = pow2101 (1.2*integ(I(v0),21.1N,21.11N)/0.01N)
.EXTRACT FILE=Power label = pow2102 (1.2*integ(I(v0),21.11N,21.12N)/0.01N)
.EXTRACT FILE=Power label = pow2103 (1.2*integ(I(v0),21.12N,21.13N)/0.01N)
.EXTRACT FILE=Power label = pow2104 (1.2*integ(I(v0),21.13N,21.14N)/0.01N)
.EXTRACT FILE=Power label = pow2105 (1.2*integ(I(v0),21.14N,21.15N)/0.01N)
.EXTRACT FILE=Power label = pow2106 (1.2*integ(I(v0),21.15N,21.16N)/0.01N)
.EXTRACT FILE=Power label = pow2107 (1.2*integ(I(v0),21.16N,21.17N)/0.01N)
.EXTRACT FILE=Power label = pow2108 (1.2*integ(I(v0),21.17N,21.18N)/0.01N)
.EXTRACT FILE=Power label = pow2109 (1.2*integ(I(v0),21.18N,21.19N)/0.01N)
.EXTRACT FILE=Power label = pow2110 (1.2*integ(I(v0),21.19N,21.2N)/0.01N)
.EXTRACT FILE=Power label = pow2111 (1.2*integ(I(v0),21.2N,21.21N)/0.01N)
.EXTRACT FILE=Power label = pow2112 (1.2*integ(I(v0),21.21N,21.22N)/0.01N)
.EXTRACT FILE=Power label = pow2113 (1.2*integ(I(v0),21.22N,21.23N)/0.01N)
.EXTRACT FILE=Power label = pow2114 (1.2*integ(I(v0),21.23N,21.24N)/0.01N)
.EXTRACT FILE=Power label = pow2115 (1.2*integ(I(v0),21.24N,21.25N)/0.01N)
.EXTRACT FILE=Power label = pow2116 (1.2*integ(I(v0),21.25N,21.26N)/0.01N)
.EXTRACT FILE=Power label = pow2117 (1.2*integ(I(v0),21.26N,21.27N)/0.01N)
.EXTRACT FILE=Power label = pow2118 (1.2*integ(I(v0),21.27N,21.28N)/0.01N)
.EXTRACT FILE=Power label = pow2119 (1.2*integ(I(v0),21.28N,21.29N)/0.01N)
.EXTRACT FILE=Power label = pow2120 (1.2*integ(I(v0),21.29N,21.3N)/0.01N)
.EXTRACT FILE=Power label = pow2121 (1.2*integ(I(v0),21.3N,21.31N)/0.01N)
.EXTRACT FILE=Power label = pow2122 (1.2*integ(I(v0),21.31N,21.32N)/0.01N)
.EXTRACT FILE=Power label = pow2123 (1.2*integ(I(v0),21.32N,21.33N)/0.01N)
.EXTRACT FILE=Power label = pow2124 (1.2*integ(I(v0),21.33N,21.34N)/0.01N)
.EXTRACT FILE=Power label = pow2125 (1.2*integ(I(v0),21.34N,21.35N)/0.01N)
.EXTRACT FILE=Power label = pow2126 (1.2*integ(I(v0),21.35N,21.36N)/0.01N)
.EXTRACT FILE=Power label = pow2127 (1.2*integ(I(v0),21.36N,21.37N)/0.01N)
.EXTRACT FILE=Power label = pow2128 (1.2*integ(I(v0),21.37N,21.38N)/0.01N)
.EXTRACT FILE=Power label = pow2129 (1.2*integ(I(v0),21.38N,21.39N)/0.01N)
.EXTRACT FILE=Power label = pow2130 (1.2*integ(I(v0),21.39N,21.4N)/0.01N)
.EXTRACT FILE=Power label = pow2131 (1.2*integ(I(v0),21.4N,21.41N)/0.01N)
.EXTRACT FILE=Power label = pow2132 (1.2*integ(I(v0),21.41N,21.42N)/0.01N)
.EXTRACT FILE=Power label = pow2133 (1.2*integ(I(v0),21.42N,21.43N)/0.01N)
.EXTRACT FILE=Power label = pow2134 (1.2*integ(I(v0),21.43N,21.44N)/0.01N)
.EXTRACT FILE=Power label = pow2135 (1.2*integ(I(v0),21.44N,21.45N)/0.01N)
.EXTRACT FILE=Power label = pow2136 (1.2*integ(I(v0),21.45N,21.46N)/0.01N)
.EXTRACT FILE=Power label = pow2137 (1.2*integ(I(v0),21.46N,21.47N)/0.01N)
.EXTRACT FILE=Power label = pow2138 (1.2*integ(I(v0),21.47N,21.48N)/0.01N)
.EXTRACT FILE=Power label = pow2139 (1.2*integ(I(v0),21.48N,21.49N)/0.01N)
.EXTRACT FILE=Power label = pow2140 (1.2*integ(I(v0),21.49N,21.5N)/0.01N)
.EXTRACT FILE=Power label = pow2141 (1.2*integ(I(v0),21.5N,21.51N)/0.01N)
.EXTRACT FILE=Power label = pow2142 (1.2*integ(I(v0),21.51N,21.52N)/0.01N)
.EXTRACT FILE=Power label = pow2143 (1.2*integ(I(v0),21.52N,21.53N)/0.01N)
.EXTRACT FILE=Power label = pow2144 (1.2*integ(I(v0),21.53N,21.54N)/0.01N)
.EXTRACT FILE=Power label = pow2145 (1.2*integ(I(v0),21.54N,21.55N)/0.01N)
.EXTRACT FILE=Power label = pow2146 (1.2*integ(I(v0),21.55N,21.56N)/0.01N)
.EXTRACT FILE=Power label = pow2147 (1.2*integ(I(v0),21.56N,21.57N)/0.01N)
.EXTRACT FILE=Power label = pow2148 (1.2*integ(I(v0),21.57N,21.58N)/0.01N)
.EXTRACT FILE=Power label = pow2149 (1.2*integ(I(v0),21.58N,21.59N)/0.01N)
.EXTRACT FILE=Power label = pow2150 (1.2*integ(I(v0),21.59N,21.6N)/0.01N)
.EXTRACT FILE=Power label = pow2151 (1.2*integ(I(v0),21.6N,21.61N)/0.01N)
.EXTRACT FILE=Power label = pow2152 (1.2*integ(I(v0),21.61N,21.62N)/0.01N)
.EXTRACT FILE=Power label = pow2153 (1.2*integ(I(v0),21.62N,21.63N)/0.01N)
.EXTRACT FILE=Power label = pow2154 (1.2*integ(I(v0),21.63N,21.64N)/0.01N)
.EXTRACT FILE=Power label = pow2155 (1.2*integ(I(v0),21.64N,21.65N)/0.01N)
.EXTRACT FILE=Power label = pow2156 (1.2*integ(I(v0),21.65N,21.66N)/0.01N)
.EXTRACT FILE=Power label = pow2157 (1.2*integ(I(v0),21.66N,21.67N)/0.01N)
.EXTRACT FILE=Power label = pow2158 (1.2*integ(I(v0),21.67N,21.68N)/0.01N)
.EXTRACT FILE=Power label = pow2159 (1.2*integ(I(v0),21.68N,21.69N)/0.01N)
.EXTRACT FILE=Power label = pow2160 (1.2*integ(I(v0),21.69N,21.7N)/0.01N)
.EXTRACT FILE=Power label = pow2161 (1.2*integ(I(v0),21.7N,21.71N)/0.01N)
.EXTRACT FILE=Power label = pow2162 (1.2*integ(I(v0),21.71N,21.72N)/0.01N)
.EXTRACT FILE=Power label = pow2163 (1.2*integ(I(v0),21.72N,21.73N)/0.01N)
.EXTRACT FILE=Power label = pow2164 (1.2*integ(I(v0),21.73N,21.74N)/0.01N)
.EXTRACT FILE=Power label = pow2165 (1.2*integ(I(v0),21.74N,21.75N)/0.01N)
.EXTRACT FILE=Power label = pow2166 (1.2*integ(I(v0),21.75N,21.76N)/0.01N)
.EXTRACT FILE=Power label = pow2167 (1.2*integ(I(v0),21.76N,21.77N)/0.01N)
.EXTRACT FILE=Power label = pow2168 (1.2*integ(I(v0),21.77N,21.78N)/0.01N)
.EXTRACT FILE=Power label = pow2169 (1.2*integ(I(v0),21.78N,21.79N)/0.01N)
.EXTRACT FILE=Power label = pow2170 (1.2*integ(I(v0),21.79N,21.8N)/0.01N)
.EXTRACT FILE=Power label = pow2171 (1.2*integ(I(v0),21.8N,21.81N)/0.01N)
.EXTRACT FILE=Power label = pow2172 (1.2*integ(I(v0),21.81N,21.82N)/0.01N)
.EXTRACT FILE=Power label = pow2173 (1.2*integ(I(v0),21.82N,21.83N)/0.01N)
.EXTRACT FILE=Power label = pow2174 (1.2*integ(I(v0),21.83N,21.84N)/0.01N)
.EXTRACT FILE=Power label = pow2175 (1.2*integ(I(v0),21.84N,21.85N)/0.01N)
.EXTRACT FILE=Power label = pow2176 (1.2*integ(I(v0),21.85N,21.86N)/0.01N)
.EXTRACT FILE=Power label = pow2177 (1.2*integ(I(v0),21.86N,21.87N)/0.01N)
.EXTRACT FILE=Power label = pow2178 (1.2*integ(I(v0),21.87N,21.88N)/0.01N)
.EXTRACT FILE=Power label = pow2179 (1.2*integ(I(v0),21.88N,21.89N)/0.01N)
.EXTRACT FILE=Power label = pow2180 (1.2*integ(I(v0),21.89N,21.9N)/0.01N)
.EXTRACT FILE=Power label = pow2181 (1.2*integ(I(v0),21.9N,21.91N)/0.01N)
.EXTRACT FILE=Power label = pow2182 (1.2*integ(I(v0),21.91N,21.92N)/0.01N)
.EXTRACT FILE=Power label = pow2183 (1.2*integ(I(v0),21.92N,21.93N)/0.01N)
.EXTRACT FILE=Power label = pow2184 (1.2*integ(I(v0),21.93N,21.94N)/0.01N)
.EXTRACT FILE=Power label = pow2185 (1.2*integ(I(v0),21.94N,21.95N)/0.01N)
.EXTRACT FILE=Power label = pow2186 (1.2*integ(I(v0),21.95N,21.96N)/0.01N)
.EXTRACT FILE=Power label = pow2187 (1.2*integ(I(v0),21.96N,21.97N)/0.01N)
.EXTRACT FILE=Power label = pow2188 (1.2*integ(I(v0),21.97N,21.98N)/0.01N)
.EXTRACT FILE=Power label = pow2189 (1.2*integ(I(v0),21.98N,21.99N)/0.01N)
.EXTRACT FILE=Power label = pow2190 (1.2*integ(I(v0),21.99N,22.0N)/0.01N)
.EXTRACT FILE=Power label = pow2191 (1.2*integ(I(v0),22.0N,22.01N)/0.01N)
.EXTRACT FILE=Power label = pow2192 (1.2*integ(I(v0),22.01N,22.02N)/0.01N)
.EXTRACT FILE=Power label = pow2193 (1.2*integ(I(v0),22.02N,22.03N)/0.01N)
.EXTRACT FILE=Power label = pow2194 (1.2*integ(I(v0),22.03N,22.04N)/0.01N)
.EXTRACT FILE=Power label = pow2195 (1.2*integ(I(v0),22.04N,22.05N)/0.01N)
.EXTRACT FILE=Power label = pow2196 (1.2*integ(I(v0),22.05N,22.06N)/0.01N)
.EXTRACT FILE=Power label = pow2197 (1.2*integ(I(v0),22.06N,22.07N)/0.01N)
.EXTRACT FILE=Power label = pow2198 (1.2*integ(I(v0),22.07N,22.08N)/0.01N)
.EXTRACT FILE=Power label = pow2199 (1.2*integ(I(v0),22.08N,22.09N)/0.01N)
.EXTRACT FILE=Power label = pow2200 (1.2*integ(I(v0),22.09N,22.1N)/0.01N)
.EXTRACT FILE=Power label = pow2201 (1.2*integ(I(v0),22.1N,22.11N)/0.01N)
.EXTRACT FILE=Power label = pow2202 (1.2*integ(I(v0),22.11N,22.12N)/0.01N)
.EXTRACT FILE=Power label = pow2203 (1.2*integ(I(v0),22.12N,22.13N)/0.01N)
.EXTRACT FILE=Power label = pow2204 (1.2*integ(I(v0),22.13N,22.14N)/0.01N)
.EXTRACT FILE=Power label = pow2205 (1.2*integ(I(v0),22.14N,22.15N)/0.01N)
.EXTRACT FILE=Power label = pow2206 (1.2*integ(I(v0),22.15N,22.16N)/0.01N)
.EXTRACT FILE=Power label = pow2207 (1.2*integ(I(v0),22.16N,22.17N)/0.01N)
.EXTRACT FILE=Power label = pow2208 (1.2*integ(I(v0),22.17N,22.18N)/0.01N)
.EXTRACT FILE=Power label = pow2209 (1.2*integ(I(v0),22.18N,22.19N)/0.01N)
.EXTRACT FILE=Power label = pow2210 (1.2*integ(I(v0),22.19N,22.2N)/0.01N)
.EXTRACT FILE=Power label = pow2211 (1.2*integ(I(v0),22.2N,22.21N)/0.01N)
.EXTRACT FILE=Power label = pow2212 (1.2*integ(I(v0),22.21N,22.22N)/0.01N)
.EXTRACT FILE=Power label = pow2213 (1.2*integ(I(v0),22.22N,22.23N)/0.01N)
.EXTRACT FILE=Power label = pow2214 (1.2*integ(I(v0),22.23N,22.24N)/0.01N)
.EXTRACT FILE=Power label = pow2215 (1.2*integ(I(v0),22.24N,22.25N)/0.01N)
.EXTRACT FILE=Power label = pow2216 (1.2*integ(I(v0),22.25N,22.26N)/0.01N)
.EXTRACT FILE=Power label = pow2217 (1.2*integ(I(v0),22.26N,22.27N)/0.01N)
.EXTRACT FILE=Power label = pow2218 (1.2*integ(I(v0),22.27N,22.28N)/0.01N)
.EXTRACT FILE=Power label = pow2219 (1.2*integ(I(v0),22.28N,22.29N)/0.01N)
.EXTRACT FILE=Power label = pow2220 (1.2*integ(I(v0),22.29N,22.3N)/0.01N)
.EXTRACT FILE=Power label = pow2221 (1.2*integ(I(v0),22.3N,22.31N)/0.01N)
.EXTRACT FILE=Power label = pow2222 (1.2*integ(I(v0),22.31N,22.32N)/0.01N)
.EXTRACT FILE=Power label = pow2223 (1.2*integ(I(v0),22.32N,22.33N)/0.01N)
.EXTRACT FILE=Power label = pow2224 (1.2*integ(I(v0),22.33N,22.34N)/0.01N)
.EXTRACT FILE=Power label = pow2225 (1.2*integ(I(v0),22.34N,22.35N)/0.01N)
.EXTRACT FILE=Power label = pow2226 (1.2*integ(I(v0),22.35N,22.36N)/0.01N)
.EXTRACT FILE=Power label = pow2227 (1.2*integ(I(v0),22.36N,22.37N)/0.01N)
.EXTRACT FILE=Power label = pow2228 (1.2*integ(I(v0),22.37N,22.38N)/0.01N)
.EXTRACT FILE=Power label = pow2229 (1.2*integ(I(v0),22.38N,22.39N)/0.01N)
.EXTRACT FILE=Power label = pow2230 (1.2*integ(I(v0),22.39N,22.4N)/0.01N)
.EXTRACT FILE=Power label = pow2231 (1.2*integ(I(v0),22.4N,22.41N)/0.01N)
.EXTRACT FILE=Power label = pow2232 (1.2*integ(I(v0),22.41N,22.42N)/0.01N)
.EXTRACT FILE=Power label = pow2233 (1.2*integ(I(v0),22.42N,22.43N)/0.01N)
.EXTRACT FILE=Power label = pow2234 (1.2*integ(I(v0),22.43N,22.44N)/0.01N)
.EXTRACT FILE=Power label = pow2235 (1.2*integ(I(v0),22.44N,22.45N)/0.01N)
.EXTRACT FILE=Power label = pow2236 (1.2*integ(I(v0),22.45N,22.46N)/0.01N)
.EXTRACT FILE=Power label = pow2237 (1.2*integ(I(v0),22.46N,22.47N)/0.01N)
.EXTRACT FILE=Power label = pow2238 (1.2*integ(I(v0),22.47N,22.48N)/0.01N)
.EXTRACT FILE=Power label = pow2239 (1.2*integ(I(v0),22.48N,22.49N)/0.01N)
.EXTRACT FILE=Power label = pow2240 (1.2*integ(I(v0),22.49N,22.5N)/0.01N)
.EXTRACT FILE=Power label = pow2241 (1.2*integ(I(v0),22.5N,22.51N)/0.01N)
.EXTRACT FILE=Power label = pow2242 (1.2*integ(I(v0),22.51N,22.52N)/0.01N)
.EXTRACT FILE=Power label = pow2243 (1.2*integ(I(v0),22.52N,22.53N)/0.01N)
.EXTRACT FILE=Power label = pow2244 (1.2*integ(I(v0),22.53N,22.54N)/0.01N)
.EXTRACT FILE=Power label = pow2245 (1.2*integ(I(v0),22.54N,22.55N)/0.01N)
.EXTRACT FILE=Power label = pow2246 (1.2*integ(I(v0),22.55N,22.56N)/0.01N)
.EXTRACT FILE=Power label = pow2247 (1.2*integ(I(v0),22.56N,22.57N)/0.01N)
.EXTRACT FILE=Power label = pow2248 (1.2*integ(I(v0),22.57N,22.58N)/0.01N)
.EXTRACT FILE=Power label = pow2249 (1.2*integ(I(v0),22.58N,22.59N)/0.01N)
.EXTRACT FILE=Power label = pow2250 (1.2*integ(I(v0),22.59N,22.6N)/0.01N)
.EXTRACT FILE=Power label = pow2251 (1.2*integ(I(v0),22.6N,22.61N)/0.01N)
.EXTRACT FILE=Power label = pow2252 (1.2*integ(I(v0),22.61N,22.62N)/0.01N)
.EXTRACT FILE=Power label = pow2253 (1.2*integ(I(v0),22.62N,22.63N)/0.01N)
.EXTRACT FILE=Power label = pow2254 (1.2*integ(I(v0),22.63N,22.64N)/0.01N)
.EXTRACT FILE=Power label = pow2255 (1.2*integ(I(v0),22.64N,22.65N)/0.01N)
.EXTRACT FILE=Power label = pow2256 (1.2*integ(I(v0),22.65N,22.66N)/0.01N)
.EXTRACT FILE=Power label = pow2257 (1.2*integ(I(v0),22.66N,22.67N)/0.01N)
.EXTRACT FILE=Power label = pow2258 (1.2*integ(I(v0),22.67N,22.68N)/0.01N)
.EXTRACT FILE=Power label = pow2259 (1.2*integ(I(v0),22.68N,22.69N)/0.01N)
.EXTRACT FILE=Power label = pow2260 (1.2*integ(I(v0),22.69N,22.7N)/0.01N)
.EXTRACT FILE=Power label = pow2261 (1.2*integ(I(v0),22.7N,22.71N)/0.01N)
.EXTRACT FILE=Power label = pow2262 (1.2*integ(I(v0),22.71N,22.72N)/0.01N)
.EXTRACT FILE=Power label = pow2263 (1.2*integ(I(v0),22.72N,22.73N)/0.01N)
.EXTRACT FILE=Power label = pow2264 (1.2*integ(I(v0),22.73N,22.74N)/0.01N)
.EXTRACT FILE=Power label = pow2265 (1.2*integ(I(v0),22.74N,22.75N)/0.01N)
.EXTRACT FILE=Power label = pow2266 (1.2*integ(I(v0),22.75N,22.76N)/0.01N)
.EXTRACT FILE=Power label = pow2267 (1.2*integ(I(v0),22.76N,22.77N)/0.01N)
.EXTRACT FILE=Power label = pow2268 (1.2*integ(I(v0),22.77N,22.78N)/0.01N)
.EXTRACT FILE=Power label = pow2269 (1.2*integ(I(v0),22.78N,22.79N)/0.01N)
.EXTRACT FILE=Power label = pow2270 (1.2*integ(I(v0),22.79N,22.8N)/0.01N)
.EXTRACT FILE=Power label = pow2271 (1.2*integ(I(v0),22.8N,22.81N)/0.01N)
.EXTRACT FILE=Power label = pow2272 (1.2*integ(I(v0),22.81N,22.82N)/0.01N)
.EXTRACT FILE=Power label = pow2273 (1.2*integ(I(v0),22.82N,22.83N)/0.01N)
.EXTRACT FILE=Power label = pow2274 (1.2*integ(I(v0),22.83N,22.84N)/0.01N)
.EXTRACT FILE=Power label = pow2275 (1.2*integ(I(v0),22.84N,22.85N)/0.01N)
.EXTRACT FILE=Power label = pow2276 (1.2*integ(I(v0),22.85N,22.86N)/0.01N)
.EXTRACT FILE=Power label = pow2277 (1.2*integ(I(v0),22.86N,22.87N)/0.01N)
.EXTRACT FILE=Power label = pow2278 (1.2*integ(I(v0),22.87N,22.88N)/0.01N)
.EXTRACT FILE=Power label = pow2279 (1.2*integ(I(v0),22.88N,22.89N)/0.01N)
.EXTRACT FILE=Power label = pow2280 (1.2*integ(I(v0),22.89N,22.9N)/0.01N)
.EXTRACT FILE=Power label = pow2281 (1.2*integ(I(v0),22.9N,22.91N)/0.01N)
.EXTRACT FILE=Power label = pow2282 (1.2*integ(I(v0),22.91N,22.92N)/0.01N)
.EXTRACT FILE=Power label = pow2283 (1.2*integ(I(v0),22.92N,22.93N)/0.01N)
.EXTRACT FILE=Power label = pow2284 (1.2*integ(I(v0),22.93N,22.94N)/0.01N)
.EXTRACT FILE=Power label = pow2285 (1.2*integ(I(v0),22.94N,22.95N)/0.01N)
.EXTRACT FILE=Power label = pow2286 (1.2*integ(I(v0),22.95N,22.96N)/0.01N)
.EXTRACT FILE=Power label = pow2287 (1.2*integ(I(v0),22.96N,22.97N)/0.01N)
.EXTRACT FILE=Power label = pow2288 (1.2*integ(I(v0),22.97N,22.98N)/0.01N)
.EXTRACT FILE=Power label = pow2289 (1.2*integ(I(v0),22.98N,22.99N)/0.01N)
.EXTRACT FILE=Power label = pow2290 (1.2*integ(I(v0),22.99N,23.0N)/0.01N)
.EXTRACT FILE=Power label = pow2291 (1.2*integ(I(v0),23.0N,23.01N)/0.01N)
.EXTRACT FILE=Power label = pow2292 (1.2*integ(I(v0),23.01N,23.02N)/0.01N)
.EXTRACT FILE=Power label = pow2293 (1.2*integ(I(v0),23.02N,23.03N)/0.01N)
.EXTRACT FILE=Power label = pow2294 (1.2*integ(I(v0),23.03N,23.04N)/0.01N)
.EXTRACT FILE=Power label = pow2295 (1.2*integ(I(v0),23.04N,23.05N)/0.01N)
.EXTRACT FILE=Power label = pow2296 (1.2*integ(I(v0),23.05N,23.06N)/0.01N)
.EXTRACT FILE=Power label = pow2297 (1.2*integ(I(v0),23.06N,23.07N)/0.01N)
.EXTRACT FILE=Power label = pow2298 (1.2*integ(I(v0),23.07N,23.08N)/0.01N)
.EXTRACT FILE=Power label = pow2299 (1.2*integ(I(v0),23.08N,23.09N)/0.01N)
.EXTRACT FILE=Power label = pow2300 (1.2*integ(I(v0),23.09N,23.1N)/0.01N)
.EXTRACT FILE=Power label = pow2301 (1.2*integ(I(v0),23.1N,23.11N)/0.01N)
.EXTRACT FILE=Power label = pow2302 (1.2*integ(I(v0),23.11N,23.12N)/0.01N)
.EXTRACT FILE=Power label = pow2303 (1.2*integ(I(v0),23.12N,23.13N)/0.01N)
.EXTRACT FILE=Power label = pow2304 (1.2*integ(I(v0),23.13N,23.14N)/0.01N)
.EXTRACT FILE=Power label = pow2305 (1.2*integ(I(v0),23.14N,23.15N)/0.01N)
.EXTRACT FILE=Power label = pow2306 (1.2*integ(I(v0),23.15N,23.16N)/0.01N)
.EXTRACT FILE=Power label = pow2307 (1.2*integ(I(v0),23.16N,23.17N)/0.01N)
.EXTRACT FILE=Power label = pow2308 (1.2*integ(I(v0),23.17N,23.18N)/0.01N)
.EXTRACT FILE=Power label = pow2309 (1.2*integ(I(v0),23.18N,23.19N)/0.01N)
.EXTRACT FILE=Power label = pow2310 (1.2*integ(I(v0),23.19N,23.2N)/0.01N)
.EXTRACT FILE=Power label = pow2311 (1.2*integ(I(v0),23.2N,23.21N)/0.01N)
.EXTRACT FILE=Power label = pow2312 (1.2*integ(I(v0),23.21N,23.22N)/0.01N)
.EXTRACT FILE=Power label = pow2313 (1.2*integ(I(v0),23.22N,23.23N)/0.01N)
.EXTRACT FILE=Power label = pow2314 (1.2*integ(I(v0),23.23N,23.24N)/0.01N)
.EXTRACT FILE=Power label = pow2315 (1.2*integ(I(v0),23.24N,23.25N)/0.01N)
.EXTRACT FILE=Power label = pow2316 (1.2*integ(I(v0),23.25N,23.26N)/0.01N)
.EXTRACT FILE=Power label = pow2317 (1.2*integ(I(v0),23.26N,23.27N)/0.01N)
.EXTRACT FILE=Power label = pow2318 (1.2*integ(I(v0),23.27N,23.28N)/0.01N)
.EXTRACT FILE=Power label = pow2319 (1.2*integ(I(v0),23.28N,23.29N)/0.01N)
.EXTRACT FILE=Power label = pow2320 (1.2*integ(I(v0),23.29N,23.3N)/0.01N)
.EXTRACT FILE=Power label = pow2321 (1.2*integ(I(v0),23.3N,23.31N)/0.01N)
.EXTRACT FILE=Power label = pow2322 (1.2*integ(I(v0),23.31N,23.32N)/0.01N)
.EXTRACT FILE=Power label = pow2323 (1.2*integ(I(v0),23.32N,23.33N)/0.01N)
.EXTRACT FILE=Power label = pow2324 (1.2*integ(I(v0),23.33N,23.34N)/0.01N)
.EXTRACT FILE=Power label = pow2325 (1.2*integ(I(v0),23.34N,23.35N)/0.01N)
.EXTRACT FILE=Power label = pow2326 (1.2*integ(I(v0),23.35N,23.36N)/0.01N)
.EXTRACT FILE=Power label = pow2327 (1.2*integ(I(v0),23.36N,23.37N)/0.01N)
.EXTRACT FILE=Power label = pow2328 (1.2*integ(I(v0),23.37N,23.38N)/0.01N)
.EXTRACT FILE=Power label = pow2329 (1.2*integ(I(v0),23.38N,23.39N)/0.01N)
.EXTRACT FILE=Power label = pow2330 (1.2*integ(I(v0),23.39N,23.4N)/0.01N)
.EXTRACT FILE=Power label = pow2331 (1.2*integ(I(v0),23.4N,23.41N)/0.01N)
.EXTRACT FILE=Power label = pow2332 (1.2*integ(I(v0),23.41N,23.42N)/0.01N)
.EXTRACT FILE=Power label = pow2333 (1.2*integ(I(v0),23.42N,23.43N)/0.01N)
.EXTRACT FILE=Power label = pow2334 (1.2*integ(I(v0),23.43N,23.44N)/0.01N)
.EXTRACT FILE=Power label = pow2335 (1.2*integ(I(v0),23.44N,23.45N)/0.01N)
.EXTRACT FILE=Power label = pow2336 (1.2*integ(I(v0),23.45N,23.46N)/0.01N)
.EXTRACT FILE=Power label = pow2337 (1.2*integ(I(v0),23.46N,23.47N)/0.01N)
.EXTRACT FILE=Power label = pow2338 (1.2*integ(I(v0),23.47N,23.48N)/0.01N)
.EXTRACT FILE=Power label = pow2339 (1.2*integ(I(v0),23.48N,23.49N)/0.01N)
.EXTRACT FILE=Power label = pow2340 (1.2*integ(I(v0),23.49N,23.5N)/0.01N)
.EXTRACT FILE=Power label = pow2341 (1.2*integ(I(v0),23.5N,23.51N)/0.01N)
.EXTRACT FILE=Power label = pow2342 (1.2*integ(I(v0),23.51N,23.52N)/0.01N)
.EXTRACT FILE=Power label = pow2343 (1.2*integ(I(v0),23.52N,23.53N)/0.01N)
.EXTRACT FILE=Power label = pow2344 (1.2*integ(I(v0),23.53N,23.54N)/0.01N)
.EXTRACT FILE=Power label = pow2345 (1.2*integ(I(v0),23.54N,23.55N)/0.01N)
.EXTRACT FILE=Power label = pow2346 (1.2*integ(I(v0),23.55N,23.56N)/0.01N)
.EXTRACT FILE=Power label = pow2347 (1.2*integ(I(v0),23.56N,23.57N)/0.01N)
.EXTRACT FILE=Power label = pow2348 (1.2*integ(I(v0),23.57N,23.58N)/0.01N)
.EXTRACT FILE=Power label = pow2349 (1.2*integ(I(v0),23.58N,23.59N)/0.01N)
.EXTRACT FILE=Power label = pow2350 (1.2*integ(I(v0),23.59N,23.6N)/0.01N)
.EXTRACT FILE=Power label = pow2351 (1.2*integ(I(v0),23.6N,23.61N)/0.01N)
.EXTRACT FILE=Power label = pow2352 (1.2*integ(I(v0),23.61N,23.62N)/0.01N)
.EXTRACT FILE=Power label = pow2353 (1.2*integ(I(v0),23.62N,23.63N)/0.01N)
.EXTRACT FILE=Power label = pow2354 (1.2*integ(I(v0),23.63N,23.64N)/0.01N)
.EXTRACT FILE=Power label = pow2355 (1.2*integ(I(v0),23.64N,23.65N)/0.01N)
.EXTRACT FILE=Power label = pow2356 (1.2*integ(I(v0),23.65N,23.66N)/0.01N)
.EXTRACT FILE=Power label = pow2357 (1.2*integ(I(v0),23.66N,23.67N)/0.01N)
.EXTRACT FILE=Power label = pow2358 (1.2*integ(I(v0),23.67N,23.68N)/0.01N)
.EXTRACT FILE=Power label = pow2359 (1.2*integ(I(v0),23.68N,23.69N)/0.01N)
.EXTRACT FILE=Power label = pow2360 (1.2*integ(I(v0),23.69N,23.7N)/0.01N)
.EXTRACT FILE=Power label = pow2361 (1.2*integ(I(v0),23.7N,23.71N)/0.01N)
.EXTRACT FILE=Power label = pow2362 (1.2*integ(I(v0),23.71N,23.72N)/0.01N)
.EXTRACT FILE=Power label = pow2363 (1.2*integ(I(v0),23.72N,23.73N)/0.01N)
.EXTRACT FILE=Power label = pow2364 (1.2*integ(I(v0),23.73N,23.74N)/0.01N)
.EXTRACT FILE=Power label = pow2365 (1.2*integ(I(v0),23.74N,23.75N)/0.01N)
.EXTRACT FILE=Power label = pow2366 (1.2*integ(I(v0),23.75N,23.76N)/0.01N)
.EXTRACT FILE=Power label = pow2367 (1.2*integ(I(v0),23.76N,23.77N)/0.01N)
.EXTRACT FILE=Power label = pow2368 (1.2*integ(I(v0),23.77N,23.78N)/0.01N)
.EXTRACT FILE=Power label = pow2369 (1.2*integ(I(v0),23.78N,23.79N)/0.01N)
.EXTRACT FILE=Power label = pow2370 (1.2*integ(I(v0),23.79N,23.8N)/0.01N)
.EXTRACT FILE=Power label = pow2371 (1.2*integ(I(v0),23.8N,23.81N)/0.01N)
.EXTRACT FILE=Power label = pow2372 (1.2*integ(I(v0),23.81N,23.82N)/0.01N)
.EXTRACT FILE=Power label = pow2373 (1.2*integ(I(v0),23.82N,23.83N)/0.01N)
.EXTRACT FILE=Power label = pow2374 (1.2*integ(I(v0),23.83N,23.84N)/0.01N)
.EXTRACT FILE=Power label = pow2375 (1.2*integ(I(v0),23.84N,23.85N)/0.01N)
.EXTRACT FILE=Power label = pow2376 (1.2*integ(I(v0),23.85N,23.86N)/0.01N)
.EXTRACT FILE=Power label = pow2377 (1.2*integ(I(v0),23.86N,23.87N)/0.01N)
.EXTRACT FILE=Power label = pow2378 (1.2*integ(I(v0),23.87N,23.88N)/0.01N)
.EXTRACT FILE=Power label = pow2379 (1.2*integ(I(v0),23.88N,23.89N)/0.01N)
.EXTRACT FILE=Power label = pow2380 (1.2*integ(I(v0),23.89N,23.9N)/0.01N)
.EXTRACT FILE=Power label = pow2381 (1.2*integ(I(v0),23.9N,23.91N)/0.01N)
.EXTRACT FILE=Power label = pow2382 (1.2*integ(I(v0),23.91N,23.92N)/0.01N)
.EXTRACT FILE=Power label = pow2383 (1.2*integ(I(v0),23.92N,23.93N)/0.01N)
.EXTRACT FILE=Power label = pow2384 (1.2*integ(I(v0),23.93N,23.94N)/0.01N)
.EXTRACT FILE=Power label = pow2385 (1.2*integ(I(v0),23.94N,23.95N)/0.01N)
.EXTRACT FILE=Power label = pow2386 (1.2*integ(I(v0),23.95N,23.96N)/0.01N)
.EXTRACT FILE=Power label = pow2387 (1.2*integ(I(v0),23.96N,23.97N)/0.01N)
.EXTRACT FILE=Power label = pow2388 (1.2*integ(I(v0),23.97N,23.98N)/0.01N)
.EXTRACT FILE=Power label = pow2389 (1.2*integ(I(v0),23.98N,23.99N)/0.01N)
.EXTRACT FILE=Power label = pow2390 (1.2*integ(I(v0),23.99N,24.0N)/0.01N)
.EXTRACT FILE=Power label = pow2391 (1.2*integ(I(v0),24.0N,24.01N)/0.01N)
.EXTRACT FILE=Power label = pow2392 (1.2*integ(I(v0),24.01N,24.02N)/0.01N)
.EXTRACT FILE=Power label = pow2393 (1.2*integ(I(v0),24.02N,24.03N)/0.01N)
.EXTRACT FILE=Power label = pow2394 (1.2*integ(I(v0),24.03N,24.04N)/0.01N)
.EXTRACT FILE=Power label = pow2395 (1.2*integ(I(v0),24.04N,24.05N)/0.01N)
.EXTRACT FILE=Power label = pow2396 (1.2*integ(I(v0),24.05N,24.06N)/0.01N)
.EXTRACT FILE=Power label = pow2397 (1.2*integ(I(v0),24.06N,24.07N)/0.01N)
.EXTRACT FILE=Power label = pow2398 (1.2*integ(I(v0),24.07N,24.08N)/0.01N)
.EXTRACT FILE=Power label = pow2399 (1.2*integ(I(v0),24.08N,24.09N)/0.01N)
.EXTRACT FILE=Power label = pow2400 (1.2*integ(I(v0),24.09N,24.1N)/0.01N)
.EXTRACT FILE=Power label = pow2401 (1.2*integ(I(v0),24.1N,24.11N)/0.01N)
.EXTRACT FILE=Power label = pow2402 (1.2*integ(I(v0),24.11N,24.12N)/0.01N)
.EXTRACT FILE=Power label = pow2403 (1.2*integ(I(v0),24.12N,24.13N)/0.01N)
.EXTRACT FILE=Power label = pow2404 (1.2*integ(I(v0),24.13N,24.14N)/0.01N)
.EXTRACT FILE=Power label = pow2405 (1.2*integ(I(v0),24.14N,24.15N)/0.01N)
.EXTRACT FILE=Power label = pow2406 (1.2*integ(I(v0),24.15N,24.16N)/0.01N)
.EXTRACT FILE=Power label = pow2407 (1.2*integ(I(v0),24.16N,24.17N)/0.01N)
.EXTRACT FILE=Power label = pow2408 (1.2*integ(I(v0),24.17N,24.18N)/0.01N)
.EXTRACT FILE=Power label = pow2409 (1.2*integ(I(v0),24.18N,24.19N)/0.01N)
.EXTRACT FILE=Power label = pow2410 (1.2*integ(I(v0),24.19N,24.2N)/0.01N)
.EXTRACT FILE=Power label = pow2411 (1.2*integ(I(v0),24.2N,24.21N)/0.01N)
.EXTRACT FILE=Power label = pow2412 (1.2*integ(I(v0),24.21N,24.22N)/0.01N)
.EXTRACT FILE=Power label = pow2413 (1.2*integ(I(v0),24.22N,24.23N)/0.01N)
.EXTRACT FILE=Power label = pow2414 (1.2*integ(I(v0),24.23N,24.24N)/0.01N)
.EXTRACT FILE=Power label = pow2415 (1.2*integ(I(v0),24.24N,24.25N)/0.01N)
.EXTRACT FILE=Power label = pow2416 (1.2*integ(I(v0),24.25N,24.26N)/0.01N)
.EXTRACT FILE=Power label = pow2417 (1.2*integ(I(v0),24.26N,24.27N)/0.01N)
.EXTRACT FILE=Power label = pow2418 (1.2*integ(I(v0),24.27N,24.28N)/0.01N)
.EXTRACT FILE=Power label = pow2419 (1.2*integ(I(v0),24.28N,24.29N)/0.01N)
.EXTRACT FILE=Power label = pow2420 (1.2*integ(I(v0),24.29N,24.3N)/0.01N)
.EXTRACT FILE=Power label = pow2421 (1.2*integ(I(v0),24.3N,24.31N)/0.01N)
.EXTRACT FILE=Power label = pow2422 (1.2*integ(I(v0),24.31N,24.32N)/0.01N)
.EXTRACT FILE=Power label = pow2423 (1.2*integ(I(v0),24.32N,24.33N)/0.01N)
.EXTRACT FILE=Power label = pow2424 (1.2*integ(I(v0),24.33N,24.34N)/0.01N)
.EXTRACT FILE=Power label = pow2425 (1.2*integ(I(v0),24.34N,24.35N)/0.01N)
.EXTRACT FILE=Power label = pow2426 (1.2*integ(I(v0),24.35N,24.36N)/0.01N)
.EXTRACT FILE=Power label = pow2427 (1.2*integ(I(v0),24.36N,24.37N)/0.01N)
.EXTRACT FILE=Power label = pow2428 (1.2*integ(I(v0),24.37N,24.38N)/0.01N)
.EXTRACT FILE=Power label = pow2429 (1.2*integ(I(v0),24.38N,24.39N)/0.01N)
.EXTRACT FILE=Power label = pow2430 (1.2*integ(I(v0),24.39N,24.4N)/0.01N)
.EXTRACT FILE=Power label = pow2431 (1.2*integ(I(v0),24.4N,24.41N)/0.01N)
.EXTRACT FILE=Power label = pow2432 (1.2*integ(I(v0),24.41N,24.42N)/0.01N)
.EXTRACT FILE=Power label = pow2433 (1.2*integ(I(v0),24.42N,24.43N)/0.01N)
.EXTRACT FILE=Power label = pow2434 (1.2*integ(I(v0),24.43N,24.44N)/0.01N)
.EXTRACT FILE=Power label = pow2435 (1.2*integ(I(v0),24.44N,24.45N)/0.01N)
.EXTRACT FILE=Power label = pow2436 (1.2*integ(I(v0),24.45N,24.46N)/0.01N)
.EXTRACT FILE=Power label = pow2437 (1.2*integ(I(v0),24.46N,24.47N)/0.01N)
.EXTRACT FILE=Power label = pow2438 (1.2*integ(I(v0),24.47N,24.48N)/0.01N)
.EXTRACT FILE=Power label = pow2439 (1.2*integ(I(v0),24.48N,24.49N)/0.01N)
.EXTRACT FILE=Power label = pow2440 (1.2*integ(I(v0),24.49N,24.5N)/0.01N)
.EXTRACT FILE=Power label = pow2441 (1.2*integ(I(v0),24.5N,24.51N)/0.01N)
.EXTRACT FILE=Power label = pow2442 (1.2*integ(I(v0),24.51N,24.52N)/0.01N)
.EXTRACT FILE=Power label = pow2443 (1.2*integ(I(v0),24.52N,24.53N)/0.01N)
.EXTRACT FILE=Power label = pow2444 (1.2*integ(I(v0),24.53N,24.54N)/0.01N)
.EXTRACT FILE=Power label = pow2445 (1.2*integ(I(v0),24.54N,24.55N)/0.01N)
.EXTRACT FILE=Power label = pow2446 (1.2*integ(I(v0),24.55N,24.56N)/0.01N)
.EXTRACT FILE=Power label = pow2447 (1.2*integ(I(v0),24.56N,24.57N)/0.01N)
.EXTRACT FILE=Power label = pow2448 (1.2*integ(I(v0),24.57N,24.58N)/0.01N)
.EXTRACT FILE=Power label = pow2449 (1.2*integ(I(v0),24.58N,24.59N)/0.01N)
.EXTRACT FILE=Power label = pow2450 (1.2*integ(I(v0),24.59N,24.6N)/0.01N)
.EXTRACT FILE=Power label = pow2451 (1.2*integ(I(v0),24.6N,24.61N)/0.01N)
.EXTRACT FILE=Power label = pow2452 (1.2*integ(I(v0),24.61N,24.62N)/0.01N)
.EXTRACT FILE=Power label = pow2453 (1.2*integ(I(v0),24.62N,24.63N)/0.01N)
.EXTRACT FILE=Power label = pow2454 (1.2*integ(I(v0),24.63N,24.64N)/0.01N)
.EXTRACT FILE=Power label = pow2455 (1.2*integ(I(v0),24.64N,24.65N)/0.01N)
.EXTRACT FILE=Power label = pow2456 (1.2*integ(I(v0),24.65N,24.66N)/0.01N)
.EXTRACT FILE=Power label = pow2457 (1.2*integ(I(v0),24.66N,24.67N)/0.01N)
.EXTRACT FILE=Power label = pow2458 (1.2*integ(I(v0),24.67N,24.68N)/0.01N)
.EXTRACT FILE=Power label = pow2459 (1.2*integ(I(v0),24.68N,24.69N)/0.01N)
.EXTRACT FILE=Power label = pow2460 (1.2*integ(I(v0),24.69N,24.7N)/0.01N)
.EXTRACT FILE=Power label = pow2461 (1.2*integ(I(v0),24.7N,24.71N)/0.01N)
.EXTRACT FILE=Power label = pow2462 (1.2*integ(I(v0),24.71N,24.72N)/0.01N)
.EXTRACT FILE=Power label = pow2463 (1.2*integ(I(v0),24.72N,24.73N)/0.01N)
.EXTRACT FILE=Power label = pow2464 (1.2*integ(I(v0),24.73N,24.74N)/0.01N)
.EXTRACT FILE=Power label = pow2465 (1.2*integ(I(v0),24.74N,24.75N)/0.01N)
.EXTRACT FILE=Power label = pow2466 (1.2*integ(I(v0),24.75N,24.76N)/0.01N)
.EXTRACT FILE=Power label = pow2467 (1.2*integ(I(v0),24.76N,24.77N)/0.01N)
.EXTRACT FILE=Power label = pow2468 (1.2*integ(I(v0),24.77N,24.78N)/0.01N)
.EXTRACT FILE=Power label = pow2469 (1.2*integ(I(v0),24.78N,24.79N)/0.01N)
.EXTRACT FILE=Power label = pow2470 (1.2*integ(I(v0),24.79N,24.8N)/0.01N)
.EXTRACT FILE=Power label = pow2471 (1.2*integ(I(v0),24.8N,24.81N)/0.01N)
.EXTRACT FILE=Power label = pow2472 (1.2*integ(I(v0),24.81N,24.82N)/0.01N)
.EXTRACT FILE=Power label = pow2473 (1.2*integ(I(v0),24.82N,24.83N)/0.01N)
.EXTRACT FILE=Power label = pow2474 (1.2*integ(I(v0),24.83N,24.84N)/0.01N)
.EXTRACT FILE=Power label = pow2475 (1.2*integ(I(v0),24.84N,24.85N)/0.01N)
.EXTRACT FILE=Power label = pow2476 (1.2*integ(I(v0),24.85N,24.86N)/0.01N)
.EXTRACT FILE=Power label = pow2477 (1.2*integ(I(v0),24.86N,24.87N)/0.01N)
.EXTRACT FILE=Power label = pow2478 (1.2*integ(I(v0),24.87N,24.88N)/0.01N)
.EXTRACT FILE=Power label = pow2479 (1.2*integ(I(v0),24.88N,24.89N)/0.01N)
.EXTRACT FILE=Power label = pow2480 (1.2*integ(I(v0),24.89N,24.9N)/0.01N)
.EXTRACT FILE=Power label = pow2481 (1.2*integ(I(v0),24.9N,24.91N)/0.01N)
.EXTRACT FILE=Power label = pow2482 (1.2*integ(I(v0),24.91N,24.92N)/0.01N)
.EXTRACT FILE=Power label = pow2483 (1.2*integ(I(v0),24.92N,24.93N)/0.01N)
.EXTRACT FILE=Power label = pow2484 (1.2*integ(I(v0),24.93N,24.94N)/0.01N)
.EXTRACT FILE=Power label = pow2485 (1.2*integ(I(v0),24.94N,24.95N)/0.01N)
.EXTRACT FILE=Power label = pow2486 (1.2*integ(I(v0),24.95N,24.96N)/0.01N)
.EXTRACT FILE=Power label = pow2487 (1.2*integ(I(v0),24.96N,24.97N)/0.01N)
.EXTRACT FILE=Power label = pow2488 (1.2*integ(I(v0),24.97N,24.98N)/0.01N)
.EXTRACT FILE=Power label = pow2489 (1.2*integ(I(v0),24.98N,24.99N)/0.01N)
.EXTRACT FILE=Power label = pow2490 (1.2*integ(I(v0),24.99N,25.0N)/0.01N)
.EXTRACT FILE=Power label = pow2491 (1.2*integ(I(v0),25.0N,25.01N)/0.01N)
.EXTRACT FILE=Power label = pow2492 (1.2*integ(I(v0),25.01N,25.02N)/0.01N)
.EXTRACT FILE=Power label = pow2493 (1.2*integ(I(v0),25.02N,25.03N)/0.01N)
.EXTRACT FILE=Power label = pow2494 (1.2*integ(I(v0),25.03N,25.04N)/0.01N)
.EXTRACT FILE=Power label = pow2495 (1.2*integ(I(v0),25.04N,25.05N)/0.01N)
.EXTRACT FILE=Power label = pow2496 (1.2*integ(I(v0),25.05N,25.06N)/0.01N)
.EXTRACT FILE=Power label = pow2497 (1.2*integ(I(v0),25.06N,25.07N)/0.01N)
.EXTRACT FILE=Power label = pow2498 (1.2*integ(I(v0),25.07N,25.08N)/0.01N)
.EXTRACT FILE=Power label = pow2499 (1.2*integ(I(v0),25.08N,25.09N)/0.01N)
.EXTRACT FILE=Power label = pow2500 (1.2*integ(I(v0),25.09N,25.1N)/0.01N)
.EXTRACT FILE=Power label = pow2501 (1.2*integ(I(v0),25.1N,25.11N)/0.01N)
.EXTRACT FILE=Power label = pow2502 (1.2*integ(I(v0),25.11N,25.12N)/0.01N)
.EXTRACT FILE=Power label = pow2503 (1.2*integ(I(v0),25.12N,25.13N)/0.01N)
.EXTRACT FILE=Power label = pow2504 (1.2*integ(I(v0),25.13N,25.14N)/0.01N)
.EXTRACT FILE=Power label = pow2505 (1.2*integ(I(v0),25.14N,25.15N)/0.01N)
.EXTRACT FILE=Power label = pow2506 (1.2*integ(I(v0),25.15N,25.16N)/0.01N)
.EXTRACT FILE=Power label = pow2507 (1.2*integ(I(v0),25.16N,25.17N)/0.01N)
.EXTRACT FILE=Power label = pow2508 (1.2*integ(I(v0),25.17N,25.18N)/0.01N)
.EXTRACT FILE=Power label = pow2509 (1.2*integ(I(v0),25.18N,25.19N)/0.01N)
.EXTRACT FILE=Power label = pow2510 (1.2*integ(I(v0),25.19N,25.2N)/0.01N)
.EXTRACT FILE=Power label = pow2511 (1.2*integ(I(v0),25.2N,25.21N)/0.01N)
.EXTRACT FILE=Power label = pow2512 (1.2*integ(I(v0),25.21N,25.22N)/0.01N)
.EXTRACT FILE=Power label = pow2513 (1.2*integ(I(v0),25.22N,25.23N)/0.01N)
.EXTRACT FILE=Power label = pow2514 (1.2*integ(I(v0),25.23N,25.24N)/0.01N)
.EXTRACT FILE=Power label = pow2515 (1.2*integ(I(v0),25.24N,25.25N)/0.01N)
.EXTRACT FILE=Power label = pow2516 (1.2*integ(I(v0),25.25N,25.26N)/0.01N)
.EXTRACT FILE=Power label = pow2517 (1.2*integ(I(v0),25.26N,25.27N)/0.01N)
.EXTRACT FILE=Power label = pow2518 (1.2*integ(I(v0),25.27N,25.28N)/0.01N)
.EXTRACT FILE=Power label = pow2519 (1.2*integ(I(v0),25.28N,25.29N)/0.01N)
.EXTRACT FILE=Power label = pow2520 (1.2*integ(I(v0),25.29N,25.3N)/0.01N)
.EXTRACT FILE=Power label = pow2521 (1.2*integ(I(v0),25.3N,25.31N)/0.01N)
.EXTRACT FILE=Power label = pow2522 (1.2*integ(I(v0),25.31N,25.32N)/0.01N)
.EXTRACT FILE=Power label = pow2523 (1.2*integ(I(v0),25.32N,25.33N)/0.01N)
.EXTRACT FILE=Power label = pow2524 (1.2*integ(I(v0),25.33N,25.34N)/0.01N)
.EXTRACT FILE=Power label = pow2525 (1.2*integ(I(v0),25.34N,25.35N)/0.01N)
.EXTRACT FILE=Power label = pow2526 (1.2*integ(I(v0),25.35N,25.36N)/0.01N)
.EXTRACT FILE=Power label = pow2527 (1.2*integ(I(v0),25.36N,25.37N)/0.01N)
.EXTRACT FILE=Power label = pow2528 (1.2*integ(I(v0),25.37N,25.38N)/0.01N)
.EXTRACT FILE=Power label = pow2529 (1.2*integ(I(v0),25.38N,25.39N)/0.01N)
.EXTRACT FILE=Power label = pow2530 (1.2*integ(I(v0),25.39N,25.4N)/0.01N)
.EXTRACT FILE=Power label = pow2531 (1.2*integ(I(v0),25.4N,25.41N)/0.01N)
.EXTRACT FILE=Power label = pow2532 (1.2*integ(I(v0),25.41N,25.42N)/0.01N)
.EXTRACT FILE=Power label = pow2533 (1.2*integ(I(v0),25.42N,25.43N)/0.01N)
.EXTRACT FILE=Power label = pow2534 (1.2*integ(I(v0),25.43N,25.44N)/0.01N)
.EXTRACT FILE=Power label = pow2535 (1.2*integ(I(v0),25.44N,25.45N)/0.01N)
.EXTRACT FILE=Power label = pow2536 (1.2*integ(I(v0),25.45N,25.46N)/0.01N)
.EXTRACT FILE=Power label = pow2537 (1.2*integ(I(v0),25.46N,25.47N)/0.01N)
.EXTRACT FILE=Power label = pow2538 (1.2*integ(I(v0),25.47N,25.48N)/0.01N)
.EXTRACT FILE=Power label = pow2539 (1.2*integ(I(v0),25.48N,25.49N)/0.01N)
.EXTRACT FILE=Power label = pow2540 (1.2*integ(I(v0),25.49N,25.5N)/0.01N)
.EXTRACT FILE=Power label = pow2541 (1.2*integ(I(v0),25.5N,25.51N)/0.01N)
.EXTRACT FILE=Power label = pow2542 (1.2*integ(I(v0),25.51N,25.52N)/0.01N)
.EXTRACT FILE=Power label = pow2543 (1.2*integ(I(v0),25.52N,25.53N)/0.01N)
.EXTRACT FILE=Power label = pow2544 (1.2*integ(I(v0),25.53N,25.54N)/0.01N)
.EXTRACT FILE=Power label = pow2545 (1.2*integ(I(v0),25.54N,25.55N)/0.01N)
.EXTRACT FILE=Power label = pow2546 (1.2*integ(I(v0),25.55N,25.56N)/0.01N)
.EXTRACT FILE=Power label = pow2547 (1.2*integ(I(v0),25.56N,25.57N)/0.01N)
.EXTRACT FILE=Power label = pow2548 (1.2*integ(I(v0),25.57N,25.58N)/0.01N)
.EXTRACT FILE=Power label = pow2549 (1.2*integ(I(v0),25.58N,25.59N)/0.01N)
.EXTRACT FILE=Power label = pow2550 (1.2*integ(I(v0),25.59N,25.6N)/0.01N)
.EXTRACT FILE=Power label = pow2551 (1.2*integ(I(v0),25.6N,25.61N)/0.01N)
.EXTRACT FILE=Power label = pow2552 (1.2*integ(I(v0),25.61N,25.62N)/0.01N)
.EXTRACT FILE=Power label = pow2553 (1.2*integ(I(v0),25.62N,25.63N)/0.01N)
.EXTRACT FILE=Power label = pow2554 (1.2*integ(I(v0),25.63N,25.64N)/0.01N)
.EXTRACT FILE=Power label = pow2555 (1.2*integ(I(v0),25.64N,25.65N)/0.01N)
.EXTRACT FILE=Power label = pow2556 (1.2*integ(I(v0),25.65N,25.66N)/0.01N)
.EXTRACT FILE=Power label = pow2557 (1.2*integ(I(v0),25.66N,25.67N)/0.01N)
.EXTRACT FILE=Power label = pow2558 (1.2*integ(I(v0),25.67N,25.68N)/0.01N)
.EXTRACT FILE=Power label = pow2559 (1.2*integ(I(v0),25.68N,25.69N)/0.01N)
.EXTRACT FILE=Power label = pow2560 (1.2*integ(I(v0),25.69N,25.7N)/0.01N)
.EXTRACT FILE=Power label = pow2561 (1.2*integ(I(v0),25.7N,25.71N)/0.01N)
.EXTRACT FILE=Power label = pow2562 (1.2*integ(I(v0),25.71N,25.72N)/0.01N)
.EXTRACT FILE=Power label = pow2563 (1.2*integ(I(v0),25.72N,25.73N)/0.01N)
.EXTRACT FILE=Power label = pow2564 (1.2*integ(I(v0),25.73N,25.74N)/0.01N)
.EXTRACT FILE=Power label = pow2565 (1.2*integ(I(v0),25.74N,25.75N)/0.01N)
.EXTRACT FILE=Power label = pow2566 (1.2*integ(I(v0),25.75N,25.76N)/0.01N)
.EXTRACT FILE=Power label = pow2567 (1.2*integ(I(v0),25.76N,25.77N)/0.01N)
.EXTRACT FILE=Power label = pow2568 (1.2*integ(I(v0),25.77N,25.78N)/0.01N)
.EXTRACT FILE=Power label = pow2569 (1.2*integ(I(v0),25.78N,25.79N)/0.01N)
.EXTRACT FILE=Power label = pow2570 (1.2*integ(I(v0),25.79N,25.8N)/0.01N)
.EXTRACT FILE=Power label = pow2571 (1.2*integ(I(v0),25.8N,25.81N)/0.01N)
.EXTRACT FILE=Power label = pow2572 (1.2*integ(I(v0),25.81N,25.82N)/0.01N)
.EXTRACT FILE=Power label = pow2573 (1.2*integ(I(v0),25.82N,25.83N)/0.01N)
.EXTRACT FILE=Power label = pow2574 (1.2*integ(I(v0),25.83N,25.84N)/0.01N)
.EXTRACT FILE=Power label = pow2575 (1.2*integ(I(v0),25.84N,25.85N)/0.01N)
.EXTRACT FILE=Power label = pow2576 (1.2*integ(I(v0),25.85N,25.86N)/0.01N)
.EXTRACT FILE=Power label = pow2577 (1.2*integ(I(v0),25.86N,25.87N)/0.01N)
.EXTRACT FILE=Power label = pow2578 (1.2*integ(I(v0),25.87N,25.88N)/0.01N)
.EXTRACT FILE=Power label = pow2579 (1.2*integ(I(v0),25.88N,25.89N)/0.01N)
.EXTRACT FILE=Power label = pow2580 (1.2*integ(I(v0),25.89N,25.9N)/0.01N)
.EXTRACT FILE=Power label = pow2581 (1.2*integ(I(v0),25.9N,25.91N)/0.01N)
.EXTRACT FILE=Power label = pow2582 (1.2*integ(I(v0),25.91N,25.92N)/0.01N)
.EXTRACT FILE=Power label = pow2583 (1.2*integ(I(v0),25.92N,25.93N)/0.01N)
.EXTRACT FILE=Power label = pow2584 (1.2*integ(I(v0),25.93N,25.94N)/0.01N)
.EXTRACT FILE=Power label = pow2585 (1.2*integ(I(v0),25.94N,25.95N)/0.01N)
.EXTRACT FILE=Power label = pow2586 (1.2*integ(I(v0),25.95N,25.96N)/0.01N)
.EXTRACT FILE=Power label = pow2587 (1.2*integ(I(v0),25.96N,25.97N)/0.01N)
.EXTRACT FILE=Power label = pow2588 (1.2*integ(I(v0),25.97N,25.98N)/0.01N)
.EXTRACT FILE=Power label = pow2589 (1.2*integ(I(v0),25.98N,25.99N)/0.01N)
.EXTRACT FILE=Power label = pow2590 (1.2*integ(I(v0),25.99N,26.0N)/0.01N)
.EXTRACT FILE=Power label = pow2591 (1.2*integ(I(v0),26.0N,26.01N)/0.01N)
.EXTRACT FILE=Power label = pow2592 (1.2*integ(I(v0),26.01N,26.02N)/0.01N)
.EXTRACT FILE=Power label = pow2593 (1.2*integ(I(v0),26.02N,26.03N)/0.01N)
.EXTRACT FILE=Power label = pow2594 (1.2*integ(I(v0),26.03N,26.04N)/0.01N)
.EXTRACT FILE=Power label = pow2595 (1.2*integ(I(v0),26.04N,26.05N)/0.01N)
.EXTRACT FILE=Power label = pow2596 (1.2*integ(I(v0),26.05N,26.06N)/0.01N)
.EXTRACT FILE=Power label = pow2597 (1.2*integ(I(v0),26.06N,26.07N)/0.01N)
.EXTRACT FILE=Power label = pow2598 (1.2*integ(I(v0),26.07N,26.08N)/0.01N)
.EXTRACT FILE=Power label = pow2599 (1.2*integ(I(v0),26.08N,26.09N)/0.01N)
.EXTRACT FILE=Power label = pow2600 (1.2*integ(I(v0),26.09N,26.1N)/0.01N)
.EXTRACT FILE=Power label = pow2601 (1.2*integ(I(v0),26.1N,26.11N)/0.01N)
.EXTRACT FILE=Power label = pow2602 (1.2*integ(I(v0),26.11N,26.12N)/0.01N)
.EXTRACT FILE=Power label = pow2603 (1.2*integ(I(v0),26.12N,26.13N)/0.01N)
.EXTRACT FILE=Power label = pow2604 (1.2*integ(I(v0),26.13N,26.14N)/0.01N)
.EXTRACT FILE=Power label = pow2605 (1.2*integ(I(v0),26.14N,26.15N)/0.01N)
.EXTRACT FILE=Power label = pow2606 (1.2*integ(I(v0),26.15N,26.16N)/0.01N)
.EXTRACT FILE=Power label = pow2607 (1.2*integ(I(v0),26.16N,26.17N)/0.01N)
.EXTRACT FILE=Power label = pow2608 (1.2*integ(I(v0),26.17N,26.18N)/0.01N)
.EXTRACT FILE=Power label = pow2609 (1.2*integ(I(v0),26.18N,26.19N)/0.01N)
.EXTRACT FILE=Power label = pow2610 (1.2*integ(I(v0),26.19N,26.2N)/0.01N)
.EXTRACT FILE=Power label = pow2611 (1.2*integ(I(v0),26.2N,26.21N)/0.01N)
.EXTRACT FILE=Power label = pow2612 (1.2*integ(I(v0),26.21N,26.22N)/0.01N)
.EXTRACT FILE=Power label = pow2613 (1.2*integ(I(v0),26.22N,26.23N)/0.01N)
.EXTRACT FILE=Power label = pow2614 (1.2*integ(I(v0),26.23N,26.24N)/0.01N)
.EXTRACT FILE=Power label = pow2615 (1.2*integ(I(v0),26.24N,26.25N)/0.01N)
.EXTRACT FILE=Power label = pow2616 (1.2*integ(I(v0),26.25N,26.26N)/0.01N)
.EXTRACT FILE=Power label = pow2617 (1.2*integ(I(v0),26.26N,26.27N)/0.01N)
.EXTRACT FILE=Power label = pow2618 (1.2*integ(I(v0),26.27N,26.28N)/0.01N)
.EXTRACT FILE=Power label = pow2619 (1.2*integ(I(v0),26.28N,26.29N)/0.01N)
.EXTRACT FILE=Power label = pow2620 (1.2*integ(I(v0),26.29N,26.3N)/0.01N)
.EXTRACT FILE=Power label = pow2621 (1.2*integ(I(v0),26.3N,26.31N)/0.01N)
.EXTRACT FILE=Power label = pow2622 (1.2*integ(I(v0),26.31N,26.32N)/0.01N)
.EXTRACT FILE=Power label = pow2623 (1.2*integ(I(v0),26.32N,26.33N)/0.01N)
.EXTRACT FILE=Power label = pow2624 (1.2*integ(I(v0),26.33N,26.34N)/0.01N)
.EXTRACT FILE=Power label = pow2625 (1.2*integ(I(v0),26.34N,26.35N)/0.01N)
.EXTRACT FILE=Power label = pow2626 (1.2*integ(I(v0),26.35N,26.36N)/0.01N)
.EXTRACT FILE=Power label = pow2627 (1.2*integ(I(v0),26.36N,26.37N)/0.01N)
.EXTRACT FILE=Power label = pow2628 (1.2*integ(I(v0),26.37N,26.38N)/0.01N)
.EXTRACT FILE=Power label = pow2629 (1.2*integ(I(v0),26.38N,26.39N)/0.01N)
.EXTRACT FILE=Power label = pow2630 (1.2*integ(I(v0),26.39N,26.4N)/0.01N)
.EXTRACT FILE=Power label = pow2631 (1.2*integ(I(v0),26.4N,26.41N)/0.01N)
.EXTRACT FILE=Power label = pow2632 (1.2*integ(I(v0),26.41N,26.42N)/0.01N)
.EXTRACT FILE=Power label = pow2633 (1.2*integ(I(v0),26.42N,26.43N)/0.01N)
.EXTRACT FILE=Power label = pow2634 (1.2*integ(I(v0),26.43N,26.44N)/0.01N)
.EXTRACT FILE=Power label = pow2635 (1.2*integ(I(v0),26.44N,26.45N)/0.01N)
.EXTRACT FILE=Power label = pow2636 (1.2*integ(I(v0),26.45N,26.46N)/0.01N)
.EXTRACT FILE=Power label = pow2637 (1.2*integ(I(v0),26.46N,26.47N)/0.01N)
.EXTRACT FILE=Power label = pow2638 (1.2*integ(I(v0),26.47N,26.48N)/0.01N)
.EXTRACT FILE=Power label = pow2639 (1.2*integ(I(v0),26.48N,26.49N)/0.01N)
.EXTRACT FILE=Power label = pow2640 (1.2*integ(I(v0),26.49N,26.5N)/0.01N)
.EXTRACT FILE=Power label = pow2641 (1.2*integ(I(v0),26.5N,26.51N)/0.01N)
.EXTRACT FILE=Power label = pow2642 (1.2*integ(I(v0),26.51N,26.52N)/0.01N)
.EXTRACT FILE=Power label = pow2643 (1.2*integ(I(v0),26.52N,26.53N)/0.01N)
.EXTRACT FILE=Power label = pow2644 (1.2*integ(I(v0),26.53N,26.54N)/0.01N)
.EXTRACT FILE=Power label = pow2645 (1.2*integ(I(v0),26.54N,26.55N)/0.01N)
.EXTRACT FILE=Power label = pow2646 (1.2*integ(I(v0),26.55N,26.56N)/0.01N)
.EXTRACT FILE=Power label = pow2647 (1.2*integ(I(v0),26.56N,26.57N)/0.01N)
.EXTRACT FILE=Power label = pow2648 (1.2*integ(I(v0),26.57N,26.58N)/0.01N)
.EXTRACT FILE=Power label = pow2649 (1.2*integ(I(v0),26.58N,26.59N)/0.01N)
.EXTRACT FILE=Power label = pow2650 (1.2*integ(I(v0),26.59N,26.6N)/0.01N)
.EXTRACT FILE=Power label = pow2651 (1.2*integ(I(v0),26.6N,26.61N)/0.01N)
.EXTRACT FILE=Power label = pow2652 (1.2*integ(I(v0),26.61N,26.62N)/0.01N)
.EXTRACT FILE=Power label = pow2653 (1.2*integ(I(v0),26.62N,26.63N)/0.01N)
.EXTRACT FILE=Power label = pow2654 (1.2*integ(I(v0),26.63N,26.64N)/0.01N)
.EXTRACT FILE=Power label = pow2655 (1.2*integ(I(v0),26.64N,26.65N)/0.01N)
.EXTRACT FILE=Power label = pow2656 (1.2*integ(I(v0),26.65N,26.66N)/0.01N)
.EXTRACT FILE=Power label = pow2657 (1.2*integ(I(v0),26.66N,26.67N)/0.01N)
.EXTRACT FILE=Power label = pow2658 (1.2*integ(I(v0),26.67N,26.68N)/0.01N)
.EXTRACT FILE=Power label = pow2659 (1.2*integ(I(v0),26.68N,26.69N)/0.01N)
.EXTRACT FILE=Power label = pow2660 (1.2*integ(I(v0),26.69N,26.7N)/0.01N)
.EXTRACT FILE=Power label = pow2661 (1.2*integ(I(v0),26.7N,26.71N)/0.01N)
.EXTRACT FILE=Power label = pow2662 (1.2*integ(I(v0),26.71N,26.72N)/0.01N)
.EXTRACT FILE=Power label = pow2663 (1.2*integ(I(v0),26.72N,26.73N)/0.01N)
.EXTRACT FILE=Power label = pow2664 (1.2*integ(I(v0),26.73N,26.74N)/0.01N)
.EXTRACT FILE=Power label = pow2665 (1.2*integ(I(v0),26.74N,26.75N)/0.01N)
.EXTRACT FILE=Power label = pow2666 (1.2*integ(I(v0),26.75N,26.76N)/0.01N)
.EXTRACT FILE=Power label = pow2667 (1.2*integ(I(v0),26.76N,26.77N)/0.01N)
.EXTRACT FILE=Power label = pow2668 (1.2*integ(I(v0),26.77N,26.78N)/0.01N)
.EXTRACT FILE=Power label = pow2669 (1.2*integ(I(v0),26.78N,26.79N)/0.01N)
.EXTRACT FILE=Power label = pow2670 (1.2*integ(I(v0),26.79N,26.8N)/0.01N)
.EXTRACT FILE=Power label = pow2671 (1.2*integ(I(v0),26.8N,26.81N)/0.01N)
.EXTRACT FILE=Power label = pow2672 (1.2*integ(I(v0),26.81N,26.82N)/0.01N)
.EXTRACT FILE=Power label = pow2673 (1.2*integ(I(v0),26.82N,26.83N)/0.01N)
.EXTRACT FILE=Power label = pow2674 (1.2*integ(I(v0),26.83N,26.84N)/0.01N)
.EXTRACT FILE=Power label = pow2675 (1.2*integ(I(v0),26.84N,26.85N)/0.01N)
.EXTRACT FILE=Power label = pow2676 (1.2*integ(I(v0),26.85N,26.86N)/0.01N)
.EXTRACT FILE=Power label = pow2677 (1.2*integ(I(v0),26.86N,26.87N)/0.01N)
.EXTRACT FILE=Power label = pow2678 (1.2*integ(I(v0),26.87N,26.88N)/0.01N)
.EXTRACT FILE=Power label = pow2679 (1.2*integ(I(v0),26.88N,26.89N)/0.01N)
.EXTRACT FILE=Power label = pow2680 (1.2*integ(I(v0),26.89N,26.9N)/0.01N)
.EXTRACT FILE=Power label = pow2681 (1.2*integ(I(v0),26.9N,26.91N)/0.01N)
.EXTRACT FILE=Power label = pow2682 (1.2*integ(I(v0),26.91N,26.92N)/0.01N)
.EXTRACT FILE=Power label = pow2683 (1.2*integ(I(v0),26.92N,26.93N)/0.01N)
.EXTRACT FILE=Power label = pow2684 (1.2*integ(I(v0),26.93N,26.94N)/0.01N)
.EXTRACT FILE=Power label = pow2685 (1.2*integ(I(v0),26.94N,26.95N)/0.01N)
.EXTRACT FILE=Power label = pow2686 (1.2*integ(I(v0),26.95N,26.96N)/0.01N)
.EXTRACT FILE=Power label = pow2687 (1.2*integ(I(v0),26.96N,26.97N)/0.01N)
.EXTRACT FILE=Power label = pow2688 (1.2*integ(I(v0),26.97N,26.98N)/0.01N)
.EXTRACT FILE=Power label = pow2689 (1.2*integ(I(v0),26.98N,26.99N)/0.01N)
.EXTRACT FILE=Power label = pow2690 (1.2*integ(I(v0),26.99N,27.0N)/0.01N)
.EXTRACT FILE=Power label = pow2691 (1.2*integ(I(v0),27.0N,27.01N)/0.01N)
.EXTRACT FILE=Power label = pow2692 (1.2*integ(I(v0),27.01N,27.02N)/0.01N)
.EXTRACT FILE=Power label = pow2693 (1.2*integ(I(v0),27.02N,27.03N)/0.01N)
.EXTRACT FILE=Power label = pow2694 (1.2*integ(I(v0),27.03N,27.04N)/0.01N)
.EXTRACT FILE=Power label = pow2695 (1.2*integ(I(v0),27.04N,27.05N)/0.01N)
.EXTRACT FILE=Power label = pow2696 (1.2*integ(I(v0),27.05N,27.06N)/0.01N)
.EXTRACT FILE=Power label = pow2697 (1.2*integ(I(v0),27.06N,27.07N)/0.01N)
.EXTRACT FILE=Power label = pow2698 (1.2*integ(I(v0),27.07N,27.08N)/0.01N)
.EXTRACT FILE=Power label = pow2699 (1.2*integ(I(v0),27.08N,27.09N)/0.01N)
.EXTRACT FILE=Power label = pow2700 (1.2*integ(I(v0),27.09N,27.1N)/0.01N)
.EXTRACT FILE=Power label = pow2701 (1.2*integ(I(v0),27.1N,27.11N)/0.01N)
.EXTRACT FILE=Power label = pow2702 (1.2*integ(I(v0),27.11N,27.12N)/0.01N)
.EXTRACT FILE=Power label = pow2703 (1.2*integ(I(v0),27.12N,27.13N)/0.01N)
.EXTRACT FILE=Power label = pow2704 (1.2*integ(I(v0),27.13N,27.14N)/0.01N)
.EXTRACT FILE=Power label = pow2705 (1.2*integ(I(v0),27.14N,27.15N)/0.01N)
.EXTRACT FILE=Power label = pow2706 (1.2*integ(I(v0),27.15N,27.16N)/0.01N)
.EXTRACT FILE=Power label = pow2707 (1.2*integ(I(v0),27.16N,27.17N)/0.01N)
.EXTRACT FILE=Power label = pow2708 (1.2*integ(I(v0),27.17N,27.18N)/0.01N)
.EXTRACT FILE=Power label = pow2709 (1.2*integ(I(v0),27.18N,27.19N)/0.01N)
.EXTRACT FILE=Power label = pow2710 (1.2*integ(I(v0),27.19N,27.2N)/0.01N)
.EXTRACT FILE=Power label = pow2711 (1.2*integ(I(v0),27.2N,27.21N)/0.01N)
.EXTRACT FILE=Power label = pow2712 (1.2*integ(I(v0),27.21N,27.22N)/0.01N)
.EXTRACT FILE=Power label = pow2713 (1.2*integ(I(v0),27.22N,27.23N)/0.01N)
.EXTRACT FILE=Power label = pow2714 (1.2*integ(I(v0),27.23N,27.24N)/0.01N)
.EXTRACT FILE=Power label = pow2715 (1.2*integ(I(v0),27.24N,27.25N)/0.01N)
.EXTRACT FILE=Power label = pow2716 (1.2*integ(I(v0),27.25N,27.26N)/0.01N)
.EXTRACT FILE=Power label = pow2717 (1.2*integ(I(v0),27.26N,27.27N)/0.01N)
.EXTRACT FILE=Power label = pow2718 (1.2*integ(I(v0),27.27N,27.28N)/0.01N)
.EXTRACT FILE=Power label = pow2719 (1.2*integ(I(v0),27.28N,27.29N)/0.01N)
.EXTRACT FILE=Power label = pow2720 (1.2*integ(I(v0),27.29N,27.3N)/0.01N)
.EXTRACT FILE=Power label = pow2721 (1.2*integ(I(v0),27.3N,27.31N)/0.01N)
.EXTRACT FILE=Power label = pow2722 (1.2*integ(I(v0),27.31N,27.32N)/0.01N)
.EXTRACT FILE=Power label = pow2723 (1.2*integ(I(v0),27.32N,27.33N)/0.01N)
.EXTRACT FILE=Power label = pow2724 (1.2*integ(I(v0),27.33N,27.34N)/0.01N)
.EXTRACT FILE=Power label = pow2725 (1.2*integ(I(v0),27.34N,27.35N)/0.01N)
.EXTRACT FILE=Power label = pow2726 (1.2*integ(I(v0),27.35N,27.36N)/0.01N)
.EXTRACT FILE=Power label = pow2727 (1.2*integ(I(v0),27.36N,27.37N)/0.01N)
.EXTRACT FILE=Power label = pow2728 (1.2*integ(I(v0),27.37N,27.38N)/0.01N)
.EXTRACT FILE=Power label = pow2729 (1.2*integ(I(v0),27.38N,27.39N)/0.01N)
.EXTRACT FILE=Power label = pow2730 (1.2*integ(I(v0),27.39N,27.4N)/0.01N)
.EXTRACT FILE=Power label = pow2731 (1.2*integ(I(v0),27.4N,27.41N)/0.01N)
.EXTRACT FILE=Power label = pow2732 (1.2*integ(I(v0),27.41N,27.42N)/0.01N)
.EXTRACT FILE=Power label = pow2733 (1.2*integ(I(v0),27.42N,27.43N)/0.01N)
.EXTRACT FILE=Power label = pow2734 (1.2*integ(I(v0),27.43N,27.44N)/0.01N)
.EXTRACT FILE=Power label = pow2735 (1.2*integ(I(v0),27.44N,27.45N)/0.01N)
.EXTRACT FILE=Power label = pow2736 (1.2*integ(I(v0),27.45N,27.46N)/0.01N)
.EXTRACT FILE=Power label = pow2737 (1.2*integ(I(v0),27.46N,27.47N)/0.01N)
.EXTRACT FILE=Power label = pow2738 (1.2*integ(I(v0),27.47N,27.48N)/0.01N)
.EXTRACT FILE=Power label = pow2739 (1.2*integ(I(v0),27.48N,27.49N)/0.01N)
.EXTRACT FILE=Power label = pow2740 (1.2*integ(I(v0),27.49N,27.5N)/0.01N)
.EXTRACT FILE=Power label = pow2741 (1.2*integ(I(v0),27.5N,27.51N)/0.01N)
.EXTRACT FILE=Power label = pow2742 (1.2*integ(I(v0),27.51N,27.52N)/0.01N)
.EXTRACT FILE=Power label = pow2743 (1.2*integ(I(v0),27.52N,27.53N)/0.01N)
.EXTRACT FILE=Power label = pow2744 (1.2*integ(I(v0),27.53N,27.54N)/0.01N)
.EXTRACT FILE=Power label = pow2745 (1.2*integ(I(v0),27.54N,27.55N)/0.01N)
.EXTRACT FILE=Power label = pow2746 (1.2*integ(I(v0),27.55N,27.56N)/0.01N)
.EXTRACT FILE=Power label = pow2747 (1.2*integ(I(v0),27.56N,27.57N)/0.01N)
.EXTRACT FILE=Power label = pow2748 (1.2*integ(I(v0),27.57N,27.58N)/0.01N)
.EXTRACT FILE=Power label = pow2749 (1.2*integ(I(v0),27.58N,27.59N)/0.01N)
.EXTRACT FILE=Power label = pow2750 (1.2*integ(I(v0),27.59N,27.6N)/0.01N)
.EXTRACT FILE=Power label = pow2751 (1.2*integ(I(v0),27.6N,27.61N)/0.01N)
.EXTRACT FILE=Power label = pow2752 (1.2*integ(I(v0),27.61N,27.62N)/0.01N)
.EXTRACT FILE=Power label = pow2753 (1.2*integ(I(v0),27.62N,27.63N)/0.01N)
.EXTRACT FILE=Power label = pow2754 (1.2*integ(I(v0),27.63N,27.64N)/0.01N)
.EXTRACT FILE=Power label = pow2755 (1.2*integ(I(v0),27.64N,27.65N)/0.01N)
.EXTRACT FILE=Power label = pow2756 (1.2*integ(I(v0),27.65N,27.66N)/0.01N)
.EXTRACT FILE=Power label = pow2757 (1.2*integ(I(v0),27.66N,27.67N)/0.01N)
.EXTRACT FILE=Power label = pow2758 (1.2*integ(I(v0),27.67N,27.68N)/0.01N)
.EXTRACT FILE=Power label = pow2759 (1.2*integ(I(v0),27.68N,27.69N)/0.01N)
.EXTRACT FILE=Power label = pow2760 (1.2*integ(I(v0),27.69N,27.7N)/0.01N)
.EXTRACT FILE=Power label = pow2761 (1.2*integ(I(v0),27.7N,27.71N)/0.01N)
.EXTRACT FILE=Power label = pow2762 (1.2*integ(I(v0),27.71N,27.72N)/0.01N)
.EXTRACT FILE=Power label = pow2763 (1.2*integ(I(v0),27.72N,27.73N)/0.01N)
.EXTRACT FILE=Power label = pow2764 (1.2*integ(I(v0),27.73N,27.74N)/0.01N)
.EXTRACT FILE=Power label = pow2765 (1.2*integ(I(v0),27.74N,27.75N)/0.01N)
.EXTRACT FILE=Power label = pow2766 (1.2*integ(I(v0),27.75N,27.76N)/0.01N)
.EXTRACT FILE=Power label = pow2767 (1.2*integ(I(v0),27.76N,27.77N)/0.01N)
.EXTRACT FILE=Power label = pow2768 (1.2*integ(I(v0),27.77N,27.78N)/0.01N)
.EXTRACT FILE=Power label = pow2769 (1.2*integ(I(v0),27.78N,27.79N)/0.01N)
.EXTRACT FILE=Power label = pow2770 (1.2*integ(I(v0),27.79N,27.8N)/0.01N)
.EXTRACT FILE=Power label = pow2771 (1.2*integ(I(v0),27.8N,27.81N)/0.01N)
.EXTRACT FILE=Power label = pow2772 (1.2*integ(I(v0),27.81N,27.82N)/0.01N)
.EXTRACT FILE=Power label = pow2773 (1.2*integ(I(v0),27.82N,27.83N)/0.01N)
.EXTRACT FILE=Power label = pow2774 (1.2*integ(I(v0),27.83N,27.84N)/0.01N)
.EXTRACT FILE=Power label = pow2775 (1.2*integ(I(v0),27.84N,27.85N)/0.01N)
.EXTRACT FILE=Power label = pow2776 (1.2*integ(I(v0),27.85N,27.86N)/0.01N)
.EXTRACT FILE=Power label = pow2777 (1.2*integ(I(v0),27.86N,27.87N)/0.01N)
.EXTRACT FILE=Power label = pow2778 (1.2*integ(I(v0),27.87N,27.88N)/0.01N)
.EXTRACT FILE=Power label = pow2779 (1.2*integ(I(v0),27.88N,27.89N)/0.01N)
.EXTRACT FILE=Power label = pow2780 (1.2*integ(I(v0),27.89N,27.9N)/0.01N)
.EXTRACT FILE=Power label = pow2781 (1.2*integ(I(v0),27.9N,27.91N)/0.01N)
.EXTRACT FILE=Power label = pow2782 (1.2*integ(I(v0),27.91N,27.92N)/0.01N)
.EXTRACT FILE=Power label = pow2783 (1.2*integ(I(v0),27.92N,27.93N)/0.01N)
.EXTRACT FILE=Power label = pow2784 (1.2*integ(I(v0),27.93N,27.94N)/0.01N)
.EXTRACT FILE=Power label = pow2785 (1.2*integ(I(v0),27.94N,27.95N)/0.01N)
.EXTRACT FILE=Power label = pow2786 (1.2*integ(I(v0),27.95N,27.96N)/0.01N)
.EXTRACT FILE=Power label = pow2787 (1.2*integ(I(v0),27.96N,27.97N)/0.01N)
.EXTRACT FILE=Power label = pow2788 (1.2*integ(I(v0),27.97N,27.98N)/0.01N)
.EXTRACT FILE=Power label = pow2789 (1.2*integ(I(v0),27.98N,27.99N)/0.01N)
.EXTRACT FILE=Power label = pow2790 (1.2*integ(I(v0),27.99N,28.0N)/0.01N)
.EXTRACT FILE=Power label = pow2791 (1.2*integ(I(v0),28.0N,28.01N)/0.01N)
.EXTRACT FILE=Power label = pow2792 (1.2*integ(I(v0),28.01N,28.02N)/0.01N)
.EXTRACT FILE=Power label = pow2793 (1.2*integ(I(v0),28.02N,28.03N)/0.01N)
.EXTRACT FILE=Power label = pow2794 (1.2*integ(I(v0),28.03N,28.04N)/0.01N)
.EXTRACT FILE=Power label = pow2795 (1.2*integ(I(v0),28.04N,28.05N)/0.01N)
.EXTRACT FILE=Power label = pow2796 (1.2*integ(I(v0),28.05N,28.06N)/0.01N)
.EXTRACT FILE=Power label = pow2797 (1.2*integ(I(v0),28.06N,28.07N)/0.01N)
.EXTRACT FILE=Power label = pow2798 (1.2*integ(I(v0),28.07N,28.08N)/0.01N)
.EXTRACT FILE=Power label = pow2799 (1.2*integ(I(v0),28.08N,28.09N)/0.01N)
.EXTRACT FILE=Power label = pow2800 (1.2*integ(I(v0),28.09N,28.1N)/0.01N)
.EXTRACT FILE=Power label = pow2801 (1.2*integ(I(v0),28.1N,28.11N)/0.01N)
.EXTRACT FILE=Power label = pow2802 (1.2*integ(I(v0),28.11N,28.12N)/0.01N)
.EXTRACT FILE=Power label = pow2803 (1.2*integ(I(v0),28.12N,28.13N)/0.01N)
.EXTRACT FILE=Power label = pow2804 (1.2*integ(I(v0),28.13N,28.14N)/0.01N)
.EXTRACT FILE=Power label = pow2805 (1.2*integ(I(v0),28.14N,28.15N)/0.01N)
.EXTRACT FILE=Power label = pow2806 (1.2*integ(I(v0),28.15N,28.16N)/0.01N)
.EXTRACT FILE=Power label = pow2807 (1.2*integ(I(v0),28.16N,28.17N)/0.01N)
.EXTRACT FILE=Power label = pow2808 (1.2*integ(I(v0),28.17N,28.18N)/0.01N)
.EXTRACT FILE=Power label = pow2809 (1.2*integ(I(v0),28.18N,28.19N)/0.01N)
.EXTRACT FILE=Power label = pow2810 (1.2*integ(I(v0),28.19N,28.2N)/0.01N)
.EXTRACT FILE=Power label = pow2811 (1.2*integ(I(v0),28.2N,28.21N)/0.01N)
.EXTRACT FILE=Power label = pow2812 (1.2*integ(I(v0),28.21N,28.22N)/0.01N)
.EXTRACT FILE=Power label = pow2813 (1.2*integ(I(v0),28.22N,28.23N)/0.01N)
.EXTRACT FILE=Power label = pow2814 (1.2*integ(I(v0),28.23N,28.24N)/0.01N)
.EXTRACT FILE=Power label = pow2815 (1.2*integ(I(v0),28.24N,28.25N)/0.01N)
.EXTRACT FILE=Power label = pow2816 (1.2*integ(I(v0),28.25N,28.26N)/0.01N)
.EXTRACT FILE=Power label = pow2817 (1.2*integ(I(v0),28.26N,28.27N)/0.01N)
.EXTRACT FILE=Power label = pow2818 (1.2*integ(I(v0),28.27N,28.28N)/0.01N)
.EXTRACT FILE=Power label = pow2819 (1.2*integ(I(v0),28.28N,28.29N)/0.01N)
.EXTRACT FILE=Power label = pow2820 (1.2*integ(I(v0),28.29N,28.3N)/0.01N)
.EXTRACT FILE=Power label = pow2821 (1.2*integ(I(v0),28.3N,28.31N)/0.01N)
.EXTRACT FILE=Power label = pow2822 (1.2*integ(I(v0),28.31N,28.32N)/0.01N)
.EXTRACT FILE=Power label = pow2823 (1.2*integ(I(v0),28.32N,28.33N)/0.01N)
.EXTRACT FILE=Power label = pow2824 (1.2*integ(I(v0),28.33N,28.34N)/0.01N)
.EXTRACT FILE=Power label = pow2825 (1.2*integ(I(v0),28.34N,28.35N)/0.01N)
.EXTRACT FILE=Power label = pow2826 (1.2*integ(I(v0),28.35N,28.36N)/0.01N)
.EXTRACT FILE=Power label = pow2827 (1.2*integ(I(v0),28.36N,28.37N)/0.01N)
.EXTRACT FILE=Power label = pow2828 (1.2*integ(I(v0),28.37N,28.38N)/0.01N)
.EXTRACT FILE=Power label = pow2829 (1.2*integ(I(v0),28.38N,28.39N)/0.01N)
.EXTRACT FILE=Power label = pow2830 (1.2*integ(I(v0),28.39N,28.4N)/0.01N)
.EXTRACT FILE=Power label = pow2831 (1.2*integ(I(v0),28.4N,28.41N)/0.01N)
.EXTRACT FILE=Power label = pow2832 (1.2*integ(I(v0),28.41N,28.42N)/0.01N)
.EXTRACT FILE=Power label = pow2833 (1.2*integ(I(v0),28.42N,28.43N)/0.01N)
.EXTRACT FILE=Power label = pow2834 (1.2*integ(I(v0),28.43N,28.44N)/0.01N)
.EXTRACT FILE=Power label = pow2835 (1.2*integ(I(v0),28.44N,28.45N)/0.01N)
.EXTRACT FILE=Power label = pow2836 (1.2*integ(I(v0),28.45N,28.46N)/0.01N)
.EXTRACT FILE=Power label = pow2837 (1.2*integ(I(v0),28.46N,28.47N)/0.01N)
.EXTRACT FILE=Power label = pow2838 (1.2*integ(I(v0),28.47N,28.48N)/0.01N)
.EXTRACT FILE=Power label = pow2839 (1.2*integ(I(v0),28.48N,28.49N)/0.01N)
.EXTRACT FILE=Power label = pow2840 (1.2*integ(I(v0),28.49N,28.5N)/0.01N)
.EXTRACT FILE=Power label = pow2841 (1.2*integ(I(v0),28.5N,28.51N)/0.01N)
.EXTRACT FILE=Power label = pow2842 (1.2*integ(I(v0),28.51N,28.52N)/0.01N)
.EXTRACT FILE=Power label = pow2843 (1.2*integ(I(v0),28.52N,28.53N)/0.01N)
.EXTRACT FILE=Power label = pow2844 (1.2*integ(I(v0),28.53N,28.54N)/0.01N)
.EXTRACT FILE=Power label = pow2845 (1.2*integ(I(v0),28.54N,28.55N)/0.01N)
.EXTRACT FILE=Power label = pow2846 (1.2*integ(I(v0),28.55N,28.56N)/0.01N)
.EXTRACT FILE=Power label = pow2847 (1.2*integ(I(v0),28.56N,28.57N)/0.01N)
.EXTRACT FILE=Power label = pow2848 (1.2*integ(I(v0),28.57N,28.58N)/0.01N)
.EXTRACT FILE=Power label = pow2849 (1.2*integ(I(v0),28.58N,28.59N)/0.01N)
.EXTRACT FILE=Power label = pow2850 (1.2*integ(I(v0),28.59N,28.6N)/0.01N)
.EXTRACT FILE=Power label = pow2851 (1.2*integ(I(v0),28.6N,28.61N)/0.01N)
.EXTRACT FILE=Power label = pow2852 (1.2*integ(I(v0),28.61N,28.62N)/0.01N)
.EXTRACT FILE=Power label = pow2853 (1.2*integ(I(v0),28.62N,28.63N)/0.01N)
.EXTRACT FILE=Power label = pow2854 (1.2*integ(I(v0),28.63N,28.64N)/0.01N)
.EXTRACT FILE=Power label = pow2855 (1.2*integ(I(v0),28.64N,28.65N)/0.01N)
.EXTRACT FILE=Power label = pow2856 (1.2*integ(I(v0),28.65N,28.66N)/0.01N)
.EXTRACT FILE=Power label = pow2857 (1.2*integ(I(v0),28.66N,28.67N)/0.01N)
.EXTRACT FILE=Power label = pow2858 (1.2*integ(I(v0),28.67N,28.68N)/0.01N)
.EXTRACT FILE=Power label = pow2859 (1.2*integ(I(v0),28.68N,28.69N)/0.01N)
.EXTRACT FILE=Power label = pow2860 (1.2*integ(I(v0),28.69N,28.7N)/0.01N)
.EXTRACT FILE=Power label = pow2861 (1.2*integ(I(v0),28.7N,28.71N)/0.01N)
.EXTRACT FILE=Power label = pow2862 (1.2*integ(I(v0),28.71N,28.72N)/0.01N)
.EXTRACT FILE=Power label = pow2863 (1.2*integ(I(v0),28.72N,28.73N)/0.01N)
.EXTRACT FILE=Power label = pow2864 (1.2*integ(I(v0),28.73N,28.74N)/0.01N)
.EXTRACT FILE=Power label = pow2865 (1.2*integ(I(v0),28.74N,28.75N)/0.01N)
.EXTRACT FILE=Power label = pow2866 (1.2*integ(I(v0),28.75N,28.76N)/0.01N)
.EXTRACT FILE=Power label = pow2867 (1.2*integ(I(v0),28.76N,28.77N)/0.01N)
.EXTRACT FILE=Power label = pow2868 (1.2*integ(I(v0),28.77N,28.78N)/0.01N)
.EXTRACT FILE=Power label = pow2869 (1.2*integ(I(v0),28.78N,28.79N)/0.01N)
.EXTRACT FILE=Power label = pow2870 (1.2*integ(I(v0),28.79N,28.8N)/0.01N)
.EXTRACT FILE=Power label = pow2871 (1.2*integ(I(v0),28.8N,28.81N)/0.01N)
.EXTRACT FILE=Power label = pow2872 (1.2*integ(I(v0),28.81N,28.82N)/0.01N)
.EXTRACT FILE=Power label = pow2873 (1.2*integ(I(v0),28.82N,28.83N)/0.01N)
.EXTRACT FILE=Power label = pow2874 (1.2*integ(I(v0),28.83N,28.84N)/0.01N)
.EXTRACT FILE=Power label = pow2875 (1.2*integ(I(v0),28.84N,28.85N)/0.01N)
.EXTRACT FILE=Power label = pow2876 (1.2*integ(I(v0),28.85N,28.86N)/0.01N)
.EXTRACT FILE=Power label = pow2877 (1.2*integ(I(v0),28.86N,28.87N)/0.01N)
.EXTRACT FILE=Power label = pow2878 (1.2*integ(I(v0),28.87N,28.88N)/0.01N)
.EXTRACT FILE=Power label = pow2879 (1.2*integ(I(v0),28.88N,28.89N)/0.01N)
.EXTRACT FILE=Power label = pow2880 (1.2*integ(I(v0),28.89N,28.9N)/0.01N)
.EXTRACT FILE=Power label = pow2881 (1.2*integ(I(v0),28.9N,28.91N)/0.01N)
.EXTRACT FILE=Power label = pow2882 (1.2*integ(I(v0),28.91N,28.92N)/0.01N)
.EXTRACT FILE=Power label = pow2883 (1.2*integ(I(v0),28.92N,28.93N)/0.01N)
.EXTRACT FILE=Power label = pow2884 (1.2*integ(I(v0),28.93N,28.94N)/0.01N)
.EXTRACT FILE=Power label = pow2885 (1.2*integ(I(v0),28.94N,28.95N)/0.01N)
.EXTRACT FILE=Power label = pow2886 (1.2*integ(I(v0),28.95N,28.96N)/0.01N)
.EXTRACT FILE=Power label = pow2887 (1.2*integ(I(v0),28.96N,28.97N)/0.01N)
.EXTRACT FILE=Power label = pow2888 (1.2*integ(I(v0),28.97N,28.98N)/0.01N)
.EXTRACT FILE=Power label = pow2889 (1.2*integ(I(v0),28.98N,28.99N)/0.01N)
.EXTRACT FILE=Power label = pow2890 (1.2*integ(I(v0),28.99N,29.0N)/0.01N)
.EXTRACT FILE=Power label = pow2891 (1.2*integ(I(v0),29.0N,29.01N)/0.01N)
.EXTRACT FILE=Power label = pow2892 (1.2*integ(I(v0),29.01N,29.02N)/0.01N)
.EXTRACT FILE=Power label = pow2893 (1.2*integ(I(v0),29.02N,29.03N)/0.01N)
.EXTRACT FILE=Power label = pow2894 (1.2*integ(I(v0),29.03N,29.04N)/0.01N)
.EXTRACT FILE=Power label = pow2895 (1.2*integ(I(v0),29.04N,29.05N)/0.01N)
.EXTRACT FILE=Power label = pow2896 (1.2*integ(I(v0),29.05N,29.06N)/0.01N)
.EXTRACT FILE=Power label = pow2897 (1.2*integ(I(v0),29.06N,29.07N)/0.01N)
.EXTRACT FILE=Power label = pow2898 (1.2*integ(I(v0),29.07N,29.08N)/0.01N)
.EXTRACT FILE=Power label = pow2899 (1.2*integ(I(v0),29.08N,29.09N)/0.01N)
.EXTRACT FILE=Power label = pow2900 (1.2*integ(I(v0),29.09N,29.1N)/0.01N)
.EXTRACT FILE=Power label = pow2901 (1.2*integ(I(v0),29.1N,29.11N)/0.01N)
.EXTRACT FILE=Power label = pow2902 (1.2*integ(I(v0),29.11N,29.12N)/0.01N)
.EXTRACT FILE=Power label = pow2903 (1.2*integ(I(v0),29.12N,29.13N)/0.01N)
.EXTRACT FILE=Power label = pow2904 (1.2*integ(I(v0),29.13N,29.14N)/0.01N)
.EXTRACT FILE=Power label = pow2905 (1.2*integ(I(v0),29.14N,29.15N)/0.01N)
.EXTRACT FILE=Power label = pow2906 (1.2*integ(I(v0),29.15N,29.16N)/0.01N)
.EXTRACT FILE=Power label = pow2907 (1.2*integ(I(v0),29.16N,29.17N)/0.01N)
.EXTRACT FILE=Power label = pow2908 (1.2*integ(I(v0),29.17N,29.18N)/0.01N)
.EXTRACT FILE=Power label = pow2909 (1.2*integ(I(v0),29.18N,29.19N)/0.01N)
.EXTRACT FILE=Power label = pow2910 (1.2*integ(I(v0),29.19N,29.2N)/0.01N)
.EXTRACT FILE=Power label = pow2911 (1.2*integ(I(v0),29.2N,29.21N)/0.01N)
.EXTRACT FILE=Power label = pow2912 (1.2*integ(I(v0),29.21N,29.22N)/0.01N)
.EXTRACT FILE=Power label = pow2913 (1.2*integ(I(v0),29.22N,29.23N)/0.01N)
.EXTRACT FILE=Power label = pow2914 (1.2*integ(I(v0),29.23N,29.24N)/0.01N)
.EXTRACT FILE=Power label = pow2915 (1.2*integ(I(v0),29.24N,29.25N)/0.01N)
.EXTRACT FILE=Power label = pow2916 (1.2*integ(I(v0),29.25N,29.26N)/0.01N)
.EXTRACT FILE=Power label = pow2917 (1.2*integ(I(v0),29.26N,29.27N)/0.01N)
.EXTRACT FILE=Power label = pow2918 (1.2*integ(I(v0),29.27N,29.28N)/0.01N)
.EXTRACT FILE=Power label = pow2919 (1.2*integ(I(v0),29.28N,29.29N)/0.01N)
.EXTRACT FILE=Power label = pow2920 (1.2*integ(I(v0),29.29N,29.3N)/0.01N)
.EXTRACT FILE=Power label = pow2921 (1.2*integ(I(v0),29.3N,29.31N)/0.01N)
.EXTRACT FILE=Power label = pow2922 (1.2*integ(I(v0),29.31N,29.32N)/0.01N)
.EXTRACT FILE=Power label = pow2923 (1.2*integ(I(v0),29.32N,29.33N)/0.01N)
.EXTRACT FILE=Power label = pow2924 (1.2*integ(I(v0),29.33N,29.34N)/0.01N)
.EXTRACT FILE=Power label = pow2925 (1.2*integ(I(v0),29.34N,29.35N)/0.01N)
.EXTRACT FILE=Power label = pow2926 (1.2*integ(I(v0),29.35N,29.36N)/0.01N)
.EXTRACT FILE=Power label = pow2927 (1.2*integ(I(v0),29.36N,29.37N)/0.01N)
.EXTRACT FILE=Power label = pow2928 (1.2*integ(I(v0),29.37N,29.38N)/0.01N)
.EXTRACT FILE=Power label = pow2929 (1.2*integ(I(v0),29.38N,29.39N)/0.01N)
.EXTRACT FILE=Power label = pow2930 (1.2*integ(I(v0),29.39N,29.4N)/0.01N)
.EXTRACT FILE=Power label = pow2931 (1.2*integ(I(v0),29.4N,29.41N)/0.01N)
.EXTRACT FILE=Power label = pow2932 (1.2*integ(I(v0),29.41N,29.42N)/0.01N)
.EXTRACT FILE=Power label = pow2933 (1.2*integ(I(v0),29.42N,29.43N)/0.01N)
.EXTRACT FILE=Power label = pow2934 (1.2*integ(I(v0),29.43N,29.44N)/0.01N)
.EXTRACT FILE=Power label = pow2935 (1.2*integ(I(v0),29.44N,29.45N)/0.01N)
.EXTRACT FILE=Power label = pow2936 (1.2*integ(I(v0),29.45N,29.46N)/0.01N)
.EXTRACT FILE=Power label = pow2937 (1.2*integ(I(v0),29.46N,29.47N)/0.01N)
.EXTRACT FILE=Power label = pow2938 (1.2*integ(I(v0),29.47N,29.48N)/0.01N)
.EXTRACT FILE=Power label = pow2939 (1.2*integ(I(v0),29.48N,29.49N)/0.01N)
.EXTRACT FILE=Power label = pow2940 (1.2*integ(I(v0),29.49N,29.5N)/0.01N)
.EXTRACT FILE=Power label = pow2941 (1.2*integ(I(v0),29.5N,29.51N)/0.01N)
.EXTRACT FILE=Power label = pow2942 (1.2*integ(I(v0),29.51N,29.52N)/0.01N)
.EXTRACT FILE=Power label = pow2943 (1.2*integ(I(v0),29.52N,29.53N)/0.01N)
.EXTRACT FILE=Power label = pow2944 (1.2*integ(I(v0),29.53N,29.54N)/0.01N)
.EXTRACT FILE=Power label = pow2945 (1.2*integ(I(v0),29.54N,29.55N)/0.01N)
.EXTRACT FILE=Power label = pow2946 (1.2*integ(I(v0),29.55N,29.56N)/0.01N)
.EXTRACT FILE=Power label = pow2947 (1.2*integ(I(v0),29.56N,29.57N)/0.01N)
.EXTRACT FILE=Power label = pow2948 (1.2*integ(I(v0),29.57N,29.58N)/0.01N)
.EXTRACT FILE=Power label = pow2949 (1.2*integ(I(v0),29.58N,29.59N)/0.01N)
.EXTRACT FILE=Power label = pow2950 (1.2*integ(I(v0),29.59N,29.6N)/0.01N)
.EXTRACT FILE=Power label = pow2951 (1.2*integ(I(v0),29.6N,29.61N)/0.01N)
.EXTRACT FILE=Power label = pow2952 (1.2*integ(I(v0),29.61N,29.62N)/0.01N)
.EXTRACT FILE=Power label = pow2953 (1.2*integ(I(v0),29.62N,29.63N)/0.01N)
.EXTRACT FILE=Power label = pow2954 (1.2*integ(I(v0),29.63N,29.64N)/0.01N)
.EXTRACT FILE=Power label = pow2955 (1.2*integ(I(v0),29.64N,29.65N)/0.01N)
.EXTRACT FILE=Power label = pow2956 (1.2*integ(I(v0),29.65N,29.66N)/0.01N)
.EXTRACT FILE=Power label = pow2957 (1.2*integ(I(v0),29.66N,29.67N)/0.01N)
.EXTRACT FILE=Power label = pow2958 (1.2*integ(I(v0),29.67N,29.68N)/0.01N)
.EXTRACT FILE=Power label = pow2959 (1.2*integ(I(v0),29.68N,29.69N)/0.01N)
.EXTRACT FILE=Power label = pow2960 (1.2*integ(I(v0),29.69N,29.7N)/0.01N)
.EXTRACT FILE=Power label = pow2961 (1.2*integ(I(v0),29.7N,29.71N)/0.01N)
.EXTRACT FILE=Power label = pow2962 (1.2*integ(I(v0),29.71N,29.72N)/0.01N)
.EXTRACT FILE=Power label = pow2963 (1.2*integ(I(v0),29.72N,29.73N)/0.01N)
.EXTRACT FILE=Power label = pow2964 (1.2*integ(I(v0),29.73N,29.74N)/0.01N)
.EXTRACT FILE=Power label = pow2965 (1.2*integ(I(v0),29.74N,29.75N)/0.01N)
.EXTRACT FILE=Power label = pow2966 (1.2*integ(I(v0),29.75N,29.76N)/0.01N)
.EXTRACT FILE=Power label = pow2967 (1.2*integ(I(v0),29.76N,29.77N)/0.01N)
.EXTRACT FILE=Power label = pow2968 (1.2*integ(I(v0),29.77N,29.78N)/0.01N)
.EXTRACT FILE=Power label = pow2969 (1.2*integ(I(v0),29.78N,29.79N)/0.01N)
.EXTRACT FILE=Power label = pow2970 (1.2*integ(I(v0),29.79N,29.8N)/0.01N)
.EXTRACT FILE=Power label = pow2971 (1.2*integ(I(v0),29.8N,29.81N)/0.01N)
.EXTRACT FILE=Power label = pow2972 (1.2*integ(I(v0),29.81N,29.82N)/0.01N)
.EXTRACT FILE=Power label = pow2973 (1.2*integ(I(v0),29.82N,29.83N)/0.01N)
.EXTRACT FILE=Power label = pow2974 (1.2*integ(I(v0),29.83N,29.84N)/0.01N)
.EXTRACT FILE=Power label = pow2975 (1.2*integ(I(v0),29.84N,29.85N)/0.01N)
.EXTRACT FILE=Power label = pow2976 (1.2*integ(I(v0),29.85N,29.86N)/0.01N)
.EXTRACT FILE=Power label = pow2977 (1.2*integ(I(v0),29.86N,29.87N)/0.01N)
.EXTRACT FILE=Power label = pow2978 (1.2*integ(I(v0),29.87N,29.88N)/0.01N)
.EXTRACT FILE=Power label = pow2979 (1.2*integ(I(v0),29.88N,29.89N)/0.01N)
.EXTRACT FILE=Power label = pow2980 (1.2*integ(I(v0),29.89N,29.9N)/0.01N)
.EXTRACT FILE=Power label = pow2981 (1.2*integ(I(v0),29.9N,29.91N)/0.01N)
.EXTRACT FILE=Power label = pow2982 (1.2*integ(I(v0),29.91N,29.92N)/0.01N)
.EXTRACT FILE=Power label = pow2983 (1.2*integ(I(v0),29.92N,29.93N)/0.01N)
.EXTRACT FILE=Power label = pow2984 (1.2*integ(I(v0),29.93N,29.94N)/0.01N)
.EXTRACT FILE=Power label = pow2985 (1.2*integ(I(v0),29.94N,29.95N)/0.01N)
.EXTRACT FILE=Power label = pow2986 (1.2*integ(I(v0),29.95N,29.96N)/0.01N)
.EXTRACT FILE=Power label = pow2987 (1.2*integ(I(v0),29.96N,29.97N)/0.01N)
.EXTRACT FILE=Power label = pow2988 (1.2*integ(I(v0),29.97N,29.98N)/0.01N)
.EXTRACT FILE=Power label = pow2989 (1.2*integ(I(v0),29.98N,29.99N)/0.01N)
.EXTRACT FILE=Power label = pow2990 (1.2*integ(I(v0),29.99N,30.0N)/0.01N)
.EXTRACT FILE=Power label = pow2991 (1.2*integ(I(v0),30.0N,30.01N)/0.01N)
.EXTRACT FILE=Power label = pow2992 (1.2*integ(I(v0),30.01N,30.02N)/0.01N)
.EXTRACT FILE=Power label = pow2993 (1.2*integ(I(v0),30.02N,30.03N)/0.01N)
.EXTRACT FILE=Power label = pow2994 (1.2*integ(I(v0),30.03N,30.04N)/0.01N)
.EXTRACT FILE=Power label = pow2995 (1.2*integ(I(v0),30.04N,30.05N)/0.01N)
.EXTRACT FILE=Power label = pow2996 (1.2*integ(I(v0),30.05N,30.06N)/0.01N)
.EXTRACT FILE=Power label = pow2997 (1.2*integ(I(v0),30.06N,30.07N)/0.01N)
.EXTRACT FILE=Power label = pow2998 (1.2*integ(I(v0),30.07N,30.08N)/0.01N)
.EXTRACT FILE=Power label = pow2999 (1.2*integ(I(v0),30.08N,30.09N)/0.01N)
.EXTRACT FILE=Power label = pow3000 (1.2*integ(I(v0),30.09N,30.1N)/0.01N)
.EXTRACT FILE=Power label = pow3001 (1.2*integ(I(v0),30.1N,30.11N)/0.01N)
.EXTRACT FILE=Power label = pow3002 (1.2*integ(I(v0),30.11N,30.12N)/0.01N)
.EXTRACT FILE=Power label = pow3003 (1.2*integ(I(v0),30.12N,30.13N)/0.01N)
.EXTRACT FILE=Power label = pow3004 (1.2*integ(I(v0),30.13N,30.14N)/0.01N)
.EXTRACT FILE=Power label = pow3005 (1.2*integ(I(v0),30.14N,30.15N)/0.01N)
.EXTRACT FILE=Power label = pow3006 (1.2*integ(I(v0),30.15N,30.16N)/0.01N)
.EXTRACT FILE=Power label = pow3007 (1.2*integ(I(v0),30.16N,30.17N)/0.01N)
.EXTRACT FILE=Power label = pow3008 (1.2*integ(I(v0),30.17N,30.18N)/0.01N)
.EXTRACT FILE=Power label = pow3009 (1.2*integ(I(v0),30.18N,30.19N)/0.01N)
.EXTRACT FILE=Power label = pow3010 (1.2*integ(I(v0),30.19N,30.2N)/0.01N)
.EXTRACT FILE=Power label = pow3011 (1.2*integ(I(v0),30.2N,30.21N)/0.01N)
.EXTRACT FILE=Power label = pow3012 (1.2*integ(I(v0),30.21N,30.22N)/0.01N)
.EXTRACT FILE=Power label = pow3013 (1.2*integ(I(v0),30.22N,30.23N)/0.01N)
.EXTRACT FILE=Power label = pow3014 (1.2*integ(I(v0),30.23N,30.24N)/0.01N)
.EXTRACT FILE=Power label = pow3015 (1.2*integ(I(v0),30.24N,30.25N)/0.01N)
.EXTRACT FILE=Power label = pow3016 (1.2*integ(I(v0),30.25N,30.26N)/0.01N)
.EXTRACT FILE=Power label = pow3017 (1.2*integ(I(v0),30.26N,30.27N)/0.01N)
.EXTRACT FILE=Power label = pow3018 (1.2*integ(I(v0),30.27N,30.28N)/0.01N)
.EXTRACT FILE=Power label = pow3019 (1.2*integ(I(v0),30.28N,30.29N)/0.01N)
.EXTRACT FILE=Power label = pow3020 (1.2*integ(I(v0),30.29N,30.3N)/0.01N)
.EXTRACT FILE=Power label = pow3021 (1.2*integ(I(v0),30.3N,30.31N)/0.01N)
.EXTRACT FILE=Power label = pow3022 (1.2*integ(I(v0),30.31N,30.32N)/0.01N)
.EXTRACT FILE=Power label = pow3023 (1.2*integ(I(v0),30.32N,30.33N)/0.01N)
.EXTRACT FILE=Power label = pow3024 (1.2*integ(I(v0),30.33N,30.34N)/0.01N)
.EXTRACT FILE=Power label = pow3025 (1.2*integ(I(v0),30.34N,30.35N)/0.01N)
.EXTRACT FILE=Power label = pow3026 (1.2*integ(I(v0),30.35N,30.36N)/0.01N)
.EXTRACT FILE=Power label = pow3027 (1.2*integ(I(v0),30.36N,30.37N)/0.01N)
.EXTRACT FILE=Power label = pow3028 (1.2*integ(I(v0),30.37N,30.38N)/0.01N)
.EXTRACT FILE=Power label = pow3029 (1.2*integ(I(v0),30.38N,30.39N)/0.01N)
.EXTRACT FILE=Power label = pow3030 (1.2*integ(I(v0),30.39N,30.4N)/0.01N)
.EXTRACT FILE=Power label = pow3031 (1.2*integ(I(v0),30.4N,30.41N)/0.01N)
.EXTRACT FILE=Power label = pow3032 (1.2*integ(I(v0),30.41N,30.42N)/0.01N)
.EXTRACT FILE=Power label = pow3033 (1.2*integ(I(v0),30.42N,30.43N)/0.01N)
.EXTRACT FILE=Power label = pow3034 (1.2*integ(I(v0),30.43N,30.44N)/0.01N)
.EXTRACT FILE=Power label = pow3035 (1.2*integ(I(v0),30.44N,30.45N)/0.01N)
.EXTRACT FILE=Power label = pow3036 (1.2*integ(I(v0),30.45N,30.46N)/0.01N)
.EXTRACT FILE=Power label = pow3037 (1.2*integ(I(v0),30.46N,30.47N)/0.01N)
.EXTRACT FILE=Power label = pow3038 (1.2*integ(I(v0),30.47N,30.48N)/0.01N)
.EXTRACT FILE=Power label = pow3039 (1.2*integ(I(v0),30.48N,30.49N)/0.01N)
.EXTRACT FILE=Power label = pow3040 (1.2*integ(I(v0),30.49N,30.5N)/0.01N)
.EXTRACT FILE=Power label = pow3041 (1.2*integ(I(v0),30.5N,30.51N)/0.01N)
.EXTRACT FILE=Power label = pow3042 (1.2*integ(I(v0),30.51N,30.52N)/0.01N)
.EXTRACT FILE=Power label = pow3043 (1.2*integ(I(v0),30.52N,30.53N)/0.01N)
.EXTRACT FILE=Power label = pow3044 (1.2*integ(I(v0),30.53N,30.54N)/0.01N)
.EXTRACT FILE=Power label = pow3045 (1.2*integ(I(v0),30.54N,30.55N)/0.01N)
.EXTRACT FILE=Power label = pow3046 (1.2*integ(I(v0),30.55N,30.56N)/0.01N)
.EXTRACT FILE=Power label = pow3047 (1.2*integ(I(v0),30.56N,30.57N)/0.01N)
.EXTRACT FILE=Power label = pow3048 (1.2*integ(I(v0),30.57N,30.58N)/0.01N)
.EXTRACT FILE=Power label = pow3049 (1.2*integ(I(v0),30.58N,30.59N)/0.01N)
.EXTRACT FILE=Power label = pow3050 (1.2*integ(I(v0),30.59N,30.6N)/0.01N)
.EXTRACT FILE=Power label = pow3051 (1.2*integ(I(v0),30.6N,30.61N)/0.01N)
.EXTRACT FILE=Power label = pow3052 (1.2*integ(I(v0),30.61N,30.62N)/0.01N)
.EXTRACT FILE=Power label = pow3053 (1.2*integ(I(v0),30.62N,30.63N)/0.01N)
.EXTRACT FILE=Power label = pow3054 (1.2*integ(I(v0),30.63N,30.64N)/0.01N)
.EXTRACT FILE=Power label = pow3055 (1.2*integ(I(v0),30.64N,30.65N)/0.01N)
.EXTRACT FILE=Power label = pow3056 (1.2*integ(I(v0),30.65N,30.66N)/0.01N)
.EXTRACT FILE=Power label = pow3057 (1.2*integ(I(v0),30.66N,30.67N)/0.01N)
.EXTRACT FILE=Power label = pow3058 (1.2*integ(I(v0),30.67N,30.68N)/0.01N)
.EXTRACT FILE=Power label = pow3059 (1.2*integ(I(v0),30.68N,30.69N)/0.01N)
.EXTRACT FILE=Power label = pow3060 (1.2*integ(I(v0),30.69N,30.7N)/0.01N)
.EXTRACT FILE=Power label = pow3061 (1.2*integ(I(v0),30.7N,30.71N)/0.01N)
.EXTRACT FILE=Power label = pow3062 (1.2*integ(I(v0),30.71N,30.72N)/0.01N)
.EXTRACT FILE=Power label = pow3063 (1.2*integ(I(v0),30.72N,30.73N)/0.01N)
.EXTRACT FILE=Power label = pow3064 (1.2*integ(I(v0),30.73N,30.74N)/0.01N)
.EXTRACT FILE=Power label = pow3065 (1.2*integ(I(v0),30.74N,30.75N)/0.01N)
.EXTRACT FILE=Power label = pow3066 (1.2*integ(I(v0),30.75N,30.76N)/0.01N)
.EXTRACT FILE=Power label = pow3067 (1.2*integ(I(v0),30.76N,30.77N)/0.01N)
.EXTRACT FILE=Power label = pow3068 (1.2*integ(I(v0),30.77N,30.78N)/0.01N)
.EXTRACT FILE=Power label = pow3069 (1.2*integ(I(v0),30.78N,30.79N)/0.01N)
.EXTRACT FILE=Power label = pow3070 (1.2*integ(I(v0),30.79N,30.8N)/0.01N)
.EXTRACT FILE=Power label = pow3071 (1.2*integ(I(v0),30.8N,30.81N)/0.01N)
.EXTRACT FILE=Power label = pow3072 (1.2*integ(I(v0),30.81N,30.82N)/0.01N)
.EXTRACT FILE=Power label = pow3073 (1.2*integ(I(v0),30.82N,30.83N)/0.01N)
.EXTRACT FILE=Power label = pow3074 (1.2*integ(I(v0),30.83N,30.84N)/0.01N)
.EXTRACT FILE=Power label = pow3075 (1.2*integ(I(v0),30.84N,30.85N)/0.01N)
.EXTRACT FILE=Power label = pow3076 (1.2*integ(I(v0),30.85N,30.86N)/0.01N)
.EXTRACT FILE=Power label = pow3077 (1.2*integ(I(v0),30.86N,30.87N)/0.01N)
.EXTRACT FILE=Power label = pow3078 (1.2*integ(I(v0),30.87N,30.88N)/0.01N)
.EXTRACT FILE=Power label = pow3079 (1.2*integ(I(v0),30.88N,30.89N)/0.01N)
.EXTRACT FILE=Power label = pow3080 (1.2*integ(I(v0),30.89N,30.9N)/0.01N)
.EXTRACT FILE=Power label = pow3081 (1.2*integ(I(v0),30.9N,30.91N)/0.01N)
.EXTRACT FILE=Power label = pow3082 (1.2*integ(I(v0),30.91N,30.92N)/0.01N)
.EXTRACT FILE=Power label = pow3083 (1.2*integ(I(v0),30.92N,30.93N)/0.01N)
.EXTRACT FILE=Power label = pow3084 (1.2*integ(I(v0),30.93N,30.94N)/0.01N)
.EXTRACT FILE=Power label = pow3085 (1.2*integ(I(v0),30.94N,30.95N)/0.01N)
.EXTRACT FILE=Power label = pow3086 (1.2*integ(I(v0),30.95N,30.96N)/0.01N)
.EXTRACT FILE=Power label = pow3087 (1.2*integ(I(v0),30.96N,30.97N)/0.01N)
.EXTRACT FILE=Power label = pow3088 (1.2*integ(I(v0),30.97N,30.98N)/0.01N)
.EXTRACT FILE=Power label = pow3089 (1.2*integ(I(v0),30.98N,30.99N)/0.01N)
.EXTRACT FILE=Power label = pow3090 (1.2*integ(I(v0),30.99N,31.0N)/0.01N)
.EXTRACT FILE=Power label = pow3091 (1.2*integ(I(v0),31.0N,31.01N)/0.01N)
.EXTRACT FILE=Power label = pow3092 (1.2*integ(I(v0),31.01N,31.02N)/0.01N)
.EXTRACT FILE=Power label = pow3093 (1.2*integ(I(v0),31.02N,31.03N)/0.01N)
.EXTRACT FILE=Power label = pow3094 (1.2*integ(I(v0),31.03N,31.04N)/0.01N)
.EXTRACT FILE=Power label = pow3095 (1.2*integ(I(v0),31.04N,31.05N)/0.01N)
.EXTRACT FILE=Power label = pow3096 (1.2*integ(I(v0),31.05N,31.06N)/0.01N)
.EXTRACT FILE=Power label = pow3097 (1.2*integ(I(v0),31.06N,31.07N)/0.01N)
.EXTRACT FILE=Power label = pow3098 (1.2*integ(I(v0),31.07N,31.08N)/0.01N)
.EXTRACT FILE=Power label = pow3099 (1.2*integ(I(v0),31.08N,31.09N)/0.01N)
.EXTRACT FILE=Power label = pow3100 (1.2*integ(I(v0),31.09N,31.1N)/0.01N)
.EXTRACT FILE=Power label = pow3101 (1.2*integ(I(v0),31.1N,31.11N)/0.01N)
.EXTRACT FILE=Power label = pow3102 (1.2*integ(I(v0),31.11N,31.12N)/0.01N)
.EXTRACT FILE=Power label = pow3103 (1.2*integ(I(v0),31.12N,31.13N)/0.01N)
.EXTRACT FILE=Power label = pow3104 (1.2*integ(I(v0),31.13N,31.14N)/0.01N)
.EXTRACT FILE=Power label = pow3105 (1.2*integ(I(v0),31.14N,31.15N)/0.01N)
.EXTRACT FILE=Power label = pow3106 (1.2*integ(I(v0),31.15N,31.16N)/0.01N)
.EXTRACT FILE=Power label = pow3107 (1.2*integ(I(v0),31.16N,31.17N)/0.01N)
.EXTRACT FILE=Power label = pow3108 (1.2*integ(I(v0),31.17N,31.18N)/0.01N)
.EXTRACT FILE=Power label = pow3109 (1.2*integ(I(v0),31.18N,31.19N)/0.01N)
.EXTRACT FILE=Power label = pow3110 (1.2*integ(I(v0),31.19N,31.2N)/0.01N)
.EXTRACT FILE=Power label = pow3111 (1.2*integ(I(v0),31.2N,31.21N)/0.01N)
.EXTRACT FILE=Power label = pow3112 (1.2*integ(I(v0),31.21N,31.22N)/0.01N)
.EXTRACT FILE=Power label = pow3113 (1.2*integ(I(v0),31.22N,31.23N)/0.01N)
.EXTRACT FILE=Power label = pow3114 (1.2*integ(I(v0),31.23N,31.24N)/0.01N)
.EXTRACT FILE=Power label = pow3115 (1.2*integ(I(v0),31.24N,31.25N)/0.01N)
.EXTRACT FILE=Power label = pow3116 (1.2*integ(I(v0),31.25N,31.26N)/0.01N)
.EXTRACT FILE=Power label = pow3117 (1.2*integ(I(v0),31.26N,31.27N)/0.01N)
.EXTRACT FILE=Power label = pow3118 (1.2*integ(I(v0),31.27N,31.28N)/0.01N)
.EXTRACT FILE=Power label = pow3119 (1.2*integ(I(v0),31.28N,31.29N)/0.01N)
.EXTRACT FILE=Power label = pow3120 (1.2*integ(I(v0),31.29N,31.3N)/0.01N)
.EXTRACT FILE=Power label = pow3121 (1.2*integ(I(v0),31.3N,31.31N)/0.01N)
.EXTRACT FILE=Power label = pow3122 (1.2*integ(I(v0),31.31N,31.32N)/0.01N)
.EXTRACT FILE=Power label = pow3123 (1.2*integ(I(v0),31.32N,31.33N)/0.01N)
.EXTRACT FILE=Power label = pow3124 (1.2*integ(I(v0),31.33N,31.34N)/0.01N)
.EXTRACT FILE=Power label = pow3125 (1.2*integ(I(v0),31.34N,31.35N)/0.01N)
.EXTRACT FILE=Power label = pow3126 (1.2*integ(I(v0),31.35N,31.36N)/0.01N)
.EXTRACT FILE=Power label = pow3127 (1.2*integ(I(v0),31.36N,31.37N)/0.01N)
.EXTRACT FILE=Power label = pow3128 (1.2*integ(I(v0),31.37N,31.38N)/0.01N)
.EXTRACT FILE=Power label = pow3129 (1.2*integ(I(v0),31.38N,31.39N)/0.01N)
.EXTRACT FILE=Power label = pow3130 (1.2*integ(I(v0),31.39N,31.4N)/0.01N)
.EXTRACT FILE=Power label = pow3131 (1.2*integ(I(v0),31.4N,31.41N)/0.01N)
.EXTRACT FILE=Power label = pow3132 (1.2*integ(I(v0),31.41N,31.42N)/0.01N)
.EXTRACT FILE=Power label = pow3133 (1.2*integ(I(v0),31.42N,31.43N)/0.01N)
.EXTRACT FILE=Power label = pow3134 (1.2*integ(I(v0),31.43N,31.44N)/0.01N)
.EXTRACT FILE=Power label = pow3135 (1.2*integ(I(v0),31.44N,31.45N)/0.01N)
.EXTRACT FILE=Power label = pow3136 (1.2*integ(I(v0),31.45N,31.46N)/0.01N)
.EXTRACT FILE=Power label = pow3137 (1.2*integ(I(v0),31.46N,31.47N)/0.01N)
.EXTRACT FILE=Power label = pow3138 (1.2*integ(I(v0),31.47N,31.48N)/0.01N)
.EXTRACT FILE=Power label = pow3139 (1.2*integ(I(v0),31.48N,31.49N)/0.01N)
.EXTRACT FILE=Power label = pow3140 (1.2*integ(I(v0),31.49N,31.5N)/0.01N)
.EXTRACT FILE=Power label = pow3141 (1.2*integ(I(v0),31.5N,31.51N)/0.01N)
.EXTRACT FILE=Power label = pow3142 (1.2*integ(I(v0),31.51N,31.52N)/0.01N)
.EXTRACT FILE=Power label = pow3143 (1.2*integ(I(v0),31.52N,31.53N)/0.01N)
.EXTRACT FILE=Power label = pow3144 (1.2*integ(I(v0),31.53N,31.54N)/0.01N)
.EXTRACT FILE=Power label = pow3145 (1.2*integ(I(v0),31.54N,31.55N)/0.01N)
.EXTRACT FILE=Power label = pow3146 (1.2*integ(I(v0),31.55N,31.56N)/0.01N)
.EXTRACT FILE=Power label = pow3147 (1.2*integ(I(v0),31.56N,31.57N)/0.01N)
.EXTRACT FILE=Power label = pow3148 (1.2*integ(I(v0),31.57N,31.58N)/0.01N)
.EXTRACT FILE=Power label = pow3149 (1.2*integ(I(v0),31.58N,31.59N)/0.01N)
.EXTRACT FILE=Power label = pow3150 (1.2*integ(I(v0),31.59N,31.6N)/0.01N)
.EXTRACT FILE=Power label = pow3151 (1.2*integ(I(v0),31.6N,31.61N)/0.01N)
.EXTRACT FILE=Power label = pow3152 (1.2*integ(I(v0),31.61N,31.62N)/0.01N)
.EXTRACT FILE=Power label = pow3153 (1.2*integ(I(v0),31.62N,31.63N)/0.01N)
.EXTRACT FILE=Power label = pow3154 (1.2*integ(I(v0),31.63N,31.64N)/0.01N)
.EXTRACT FILE=Power label = pow3155 (1.2*integ(I(v0),31.64N,31.65N)/0.01N)
.EXTRACT FILE=Power label = pow3156 (1.2*integ(I(v0),31.65N,31.66N)/0.01N)
.EXTRACT FILE=Power label = pow3157 (1.2*integ(I(v0),31.66N,31.67N)/0.01N)
.EXTRACT FILE=Power label = pow3158 (1.2*integ(I(v0),31.67N,31.68N)/0.01N)
.EXTRACT FILE=Power label = pow3159 (1.2*integ(I(v0),31.68N,31.69N)/0.01N)
.EXTRACT FILE=Power label = pow3160 (1.2*integ(I(v0),31.69N,31.7N)/0.01N)
.EXTRACT FILE=Power label = pow3161 (1.2*integ(I(v0),31.7N,31.71N)/0.01N)
.EXTRACT FILE=Power label = pow3162 (1.2*integ(I(v0),31.71N,31.72N)/0.01N)
.EXTRACT FILE=Power label = pow3163 (1.2*integ(I(v0),31.72N,31.73N)/0.01N)
.EXTRACT FILE=Power label = pow3164 (1.2*integ(I(v0),31.73N,31.74N)/0.01N)
.EXTRACT FILE=Power label = pow3165 (1.2*integ(I(v0),31.74N,31.75N)/0.01N)
.EXTRACT FILE=Power label = pow3166 (1.2*integ(I(v0),31.75N,31.76N)/0.01N)
.EXTRACT FILE=Power label = pow3167 (1.2*integ(I(v0),31.76N,31.77N)/0.01N)
.EXTRACT FILE=Power label = pow3168 (1.2*integ(I(v0),31.77N,31.78N)/0.01N)
.EXTRACT FILE=Power label = pow3169 (1.2*integ(I(v0),31.78N,31.79N)/0.01N)
.EXTRACT FILE=Power label = pow3170 (1.2*integ(I(v0),31.79N,31.8N)/0.01N)
.EXTRACT FILE=Power label = pow3171 (1.2*integ(I(v0),31.8N,31.81N)/0.01N)
.EXTRACT FILE=Power label = pow3172 (1.2*integ(I(v0),31.81N,31.82N)/0.01N)
.EXTRACT FILE=Power label = pow3173 (1.2*integ(I(v0),31.82N,31.83N)/0.01N)
.EXTRACT FILE=Power label = pow3174 (1.2*integ(I(v0),31.83N,31.84N)/0.01N)
.EXTRACT FILE=Power label = pow3175 (1.2*integ(I(v0),31.84N,31.85N)/0.01N)
.EXTRACT FILE=Power label = pow3176 (1.2*integ(I(v0),31.85N,31.86N)/0.01N)
.EXTRACT FILE=Power label = pow3177 (1.2*integ(I(v0),31.86N,31.87N)/0.01N)
.EXTRACT FILE=Power label = pow3178 (1.2*integ(I(v0),31.87N,31.88N)/0.01N)
.EXTRACT FILE=Power label = pow3179 (1.2*integ(I(v0),31.88N,31.89N)/0.01N)
.EXTRACT FILE=Power label = pow3180 (1.2*integ(I(v0),31.89N,31.9N)/0.01N)
.EXTRACT FILE=Power label = pow3181 (1.2*integ(I(v0),31.9N,31.91N)/0.01N)
.EXTRACT FILE=Power label = pow3182 (1.2*integ(I(v0),31.91N,31.92N)/0.01N)
.EXTRACT FILE=Power label = pow3183 (1.2*integ(I(v0),31.92N,31.93N)/0.01N)
.EXTRACT FILE=Power label = pow3184 (1.2*integ(I(v0),31.93N,31.94N)/0.01N)
.EXTRACT FILE=Power label = pow3185 (1.2*integ(I(v0),31.94N,31.95N)/0.01N)
.EXTRACT FILE=Power label = pow3186 (1.2*integ(I(v0),31.95N,31.96N)/0.01N)
.EXTRACT FILE=Power label = pow3187 (1.2*integ(I(v0),31.96N,31.97N)/0.01N)
.EXTRACT FILE=Power label = pow3188 (1.2*integ(I(v0),31.97N,31.98N)/0.01N)
.EXTRACT FILE=Power label = pow3189 (1.2*integ(I(v0),31.98N,31.99N)/0.01N)
.EXTRACT FILE=Power label = pow3190 (1.2*integ(I(v0),31.99N,32.0N)/0.01N)
.EXTRACT FILE=Power label = pow3191 (1.2*integ(I(v0),32.0N,32.01N)/0.01N)
.EXTRACT FILE=Power label = pow3192 (1.2*integ(I(v0),32.01N,32.02N)/0.01N)
.EXTRACT FILE=Power label = pow3193 (1.2*integ(I(v0),32.02N,32.03N)/0.01N)
.EXTRACT FILE=Power label = pow3194 (1.2*integ(I(v0),32.03N,32.04N)/0.01N)
.EXTRACT FILE=Power label = pow3195 (1.2*integ(I(v0),32.04N,32.05N)/0.01N)
.EXTRACT FILE=Power label = pow3196 (1.2*integ(I(v0),32.05N,32.06N)/0.01N)
.EXTRACT FILE=Power label = pow3197 (1.2*integ(I(v0),32.06N,32.07N)/0.01N)
.EXTRACT FILE=Power label = pow3198 (1.2*integ(I(v0),32.07N,32.08N)/0.01N)
.EXTRACT FILE=Power label = pow3199 (1.2*integ(I(v0),32.08N,32.09N)/0.01N)
.EXTRACT FILE=Power label = pow3200 (1.2*integ(I(v0),32.09N,32.1N)/0.01N)
.EXTRACT FILE=Power label = pow3201 (1.2*integ(I(v0),32.1N,32.11N)/0.01N)
.EXTRACT FILE=Power label = pow3202 (1.2*integ(I(v0),32.11N,32.12N)/0.01N)
.EXTRACT FILE=Power label = pow3203 (1.2*integ(I(v0),32.12N,32.13N)/0.01N)
.EXTRACT FILE=Power label = pow3204 (1.2*integ(I(v0),32.13N,32.14N)/0.01N)
.EXTRACT FILE=Power label = pow3205 (1.2*integ(I(v0),32.14N,32.15N)/0.01N)
.EXTRACT FILE=Power label = pow3206 (1.2*integ(I(v0),32.15N,32.16N)/0.01N)
.EXTRACT FILE=Power label = pow3207 (1.2*integ(I(v0),32.16N,32.17N)/0.01N)
.EXTRACT FILE=Power label = pow3208 (1.2*integ(I(v0),32.17N,32.18N)/0.01N)
.EXTRACT FILE=Power label = pow3209 (1.2*integ(I(v0),32.18N,32.19N)/0.01N)
.EXTRACT FILE=Power label = pow3210 (1.2*integ(I(v0),32.19N,32.2N)/0.01N)
.EXTRACT FILE=Power label = pow3211 (1.2*integ(I(v0),32.2N,32.21N)/0.01N)
.EXTRACT FILE=Power label = pow3212 (1.2*integ(I(v0),32.21N,32.22N)/0.01N)
.EXTRACT FILE=Power label = pow3213 (1.2*integ(I(v0),32.22N,32.23N)/0.01N)
.EXTRACT FILE=Power label = pow3214 (1.2*integ(I(v0),32.23N,32.24N)/0.01N)
.EXTRACT FILE=Power label = pow3215 (1.2*integ(I(v0),32.24N,32.25N)/0.01N)
.EXTRACT FILE=Power label = pow3216 (1.2*integ(I(v0),32.25N,32.26N)/0.01N)
.EXTRACT FILE=Power label = pow3217 (1.2*integ(I(v0),32.26N,32.27N)/0.01N)
.EXTRACT FILE=Power label = pow3218 (1.2*integ(I(v0),32.27N,32.28N)/0.01N)
.EXTRACT FILE=Power label = pow3219 (1.2*integ(I(v0),32.28N,32.29N)/0.01N)
.EXTRACT FILE=Power label = pow3220 (1.2*integ(I(v0),32.29N,32.3N)/0.01N)
.EXTRACT FILE=Power label = pow3221 (1.2*integ(I(v0),32.3N,32.31N)/0.01N)
.EXTRACT FILE=Power label = pow3222 (1.2*integ(I(v0),32.31N,32.32N)/0.01N)
.EXTRACT FILE=Power label = pow3223 (1.2*integ(I(v0),32.32N,32.33N)/0.01N)
.EXTRACT FILE=Power label = pow3224 (1.2*integ(I(v0),32.33N,32.34N)/0.01N)
.EXTRACT FILE=Power label = pow3225 (1.2*integ(I(v0),32.34N,32.35N)/0.01N)
.EXTRACT FILE=Power label = pow3226 (1.2*integ(I(v0),32.35N,32.36N)/0.01N)
.EXTRACT FILE=Power label = pow3227 (1.2*integ(I(v0),32.36N,32.37N)/0.01N)
.EXTRACT FILE=Power label = pow3228 (1.2*integ(I(v0),32.37N,32.38N)/0.01N)
.EXTRACT FILE=Power label = pow3229 (1.2*integ(I(v0),32.38N,32.39N)/0.01N)
.EXTRACT FILE=Power label = pow3230 (1.2*integ(I(v0),32.39N,32.4N)/0.01N)
.EXTRACT FILE=Power label = pow3231 (1.2*integ(I(v0),32.4N,32.41N)/0.01N)
.EXTRACT FILE=Power label = pow3232 (1.2*integ(I(v0),32.41N,32.42N)/0.01N)
.EXTRACT FILE=Power label = pow3233 (1.2*integ(I(v0),32.42N,32.43N)/0.01N)
.EXTRACT FILE=Power label = pow3234 (1.2*integ(I(v0),32.43N,32.44N)/0.01N)
.EXTRACT FILE=Power label = pow3235 (1.2*integ(I(v0),32.44N,32.45N)/0.01N)
.EXTRACT FILE=Power label = pow3236 (1.2*integ(I(v0),32.45N,32.46N)/0.01N)
.EXTRACT FILE=Power label = pow3237 (1.2*integ(I(v0),32.46N,32.47N)/0.01N)
.EXTRACT FILE=Power label = pow3238 (1.2*integ(I(v0),32.47N,32.48N)/0.01N)
.EXTRACT FILE=Power label = pow3239 (1.2*integ(I(v0),32.48N,32.49N)/0.01N)
.EXTRACT FILE=Power label = pow3240 (1.2*integ(I(v0),32.49N,32.5N)/0.01N)
.EXTRACT FILE=Power label = pow3241 (1.2*integ(I(v0),32.5N,32.51N)/0.01N)
.EXTRACT FILE=Power label = pow3242 (1.2*integ(I(v0),32.51N,32.52N)/0.01N)
.EXTRACT FILE=Power label = pow3243 (1.2*integ(I(v0),32.52N,32.53N)/0.01N)
.EXTRACT FILE=Power label = pow3244 (1.2*integ(I(v0),32.53N,32.54N)/0.01N)
.EXTRACT FILE=Power label = pow3245 (1.2*integ(I(v0),32.54N,32.55N)/0.01N)
.EXTRACT FILE=Power label = pow3246 (1.2*integ(I(v0),32.55N,32.56N)/0.01N)
.EXTRACT FILE=Power label = pow3247 (1.2*integ(I(v0),32.56N,32.57N)/0.01N)
.EXTRACT FILE=Power label = pow3248 (1.2*integ(I(v0),32.57N,32.58N)/0.01N)
.EXTRACT FILE=Power label = pow3249 (1.2*integ(I(v0),32.58N,32.59N)/0.01N)
.EXTRACT FILE=Power label = pow3250 (1.2*integ(I(v0),32.59N,32.6N)/0.01N)
.EXTRACT FILE=Power label = pow3251 (1.2*integ(I(v0),32.6N,32.61N)/0.01N)
.EXTRACT FILE=Power label = pow3252 (1.2*integ(I(v0),32.61N,32.62N)/0.01N)
.EXTRACT FILE=Power label = pow3253 (1.2*integ(I(v0),32.62N,32.63N)/0.01N)
.EXTRACT FILE=Power label = pow3254 (1.2*integ(I(v0),32.63N,32.64N)/0.01N)
.EXTRACT FILE=Power label = pow3255 (1.2*integ(I(v0),32.64N,32.65N)/0.01N)
.EXTRACT FILE=Power label = pow3256 (1.2*integ(I(v0),32.65N,32.66N)/0.01N)
.EXTRACT FILE=Power label = pow3257 (1.2*integ(I(v0),32.66N,32.67N)/0.01N)
.EXTRACT FILE=Power label = pow3258 (1.2*integ(I(v0),32.67N,32.68N)/0.01N)
.EXTRACT FILE=Power label = pow3259 (1.2*integ(I(v0),32.68N,32.69N)/0.01N)
.EXTRACT FILE=Power label = pow3260 (1.2*integ(I(v0),32.69N,32.7N)/0.01N)
.EXTRACT FILE=Power label = pow3261 (1.2*integ(I(v0),32.7N,32.71N)/0.01N)
.EXTRACT FILE=Power label = pow3262 (1.2*integ(I(v0),32.71N,32.72N)/0.01N)
.EXTRACT FILE=Power label = pow3263 (1.2*integ(I(v0),32.72N,32.73N)/0.01N)
.EXTRACT FILE=Power label = pow3264 (1.2*integ(I(v0),32.73N,32.74N)/0.01N)
.EXTRACT FILE=Power label = pow3265 (1.2*integ(I(v0),32.74N,32.75N)/0.01N)
.EXTRACT FILE=Power label = pow3266 (1.2*integ(I(v0),32.75N,32.76N)/0.01N)
.EXTRACT FILE=Power label = pow3267 (1.2*integ(I(v0),32.76N,32.77N)/0.01N)
.EXTRACT FILE=Power label = pow3268 (1.2*integ(I(v0),32.77N,32.78N)/0.01N)
.EXTRACT FILE=Power label = pow3269 (1.2*integ(I(v0),32.78N,32.79N)/0.01N)
.EXTRACT FILE=Power label = pow3270 (1.2*integ(I(v0),32.79N,32.8N)/0.01N)
.EXTRACT FILE=Power label = pow3271 (1.2*integ(I(v0),32.8N,32.81N)/0.01N)
.EXTRACT FILE=Power label = pow3272 (1.2*integ(I(v0),32.81N,32.82N)/0.01N)
.EXTRACT FILE=Power label = pow3273 (1.2*integ(I(v0),32.82N,32.83N)/0.01N)
.EXTRACT FILE=Power label = pow3274 (1.2*integ(I(v0),32.83N,32.84N)/0.01N)
.EXTRACT FILE=Power label = pow3275 (1.2*integ(I(v0),32.84N,32.85N)/0.01N)
.EXTRACT FILE=Power label = pow3276 (1.2*integ(I(v0),32.85N,32.86N)/0.01N)
.EXTRACT FILE=Power label = pow3277 (1.2*integ(I(v0),32.86N,32.87N)/0.01N)
.EXTRACT FILE=Power label = pow3278 (1.2*integ(I(v0),32.87N,32.88N)/0.01N)
.EXTRACT FILE=Power label = pow3279 (1.2*integ(I(v0),32.88N,32.89N)/0.01N)
.EXTRACT FILE=Power label = pow3280 (1.2*integ(I(v0),32.89N,32.9N)/0.01N)
.EXTRACT FILE=Power label = pow3281 (1.2*integ(I(v0),32.9N,32.91N)/0.01N)
.EXTRACT FILE=Power label = pow3282 (1.2*integ(I(v0),32.91N,32.92N)/0.01N)
.EXTRACT FILE=Power label = pow3283 (1.2*integ(I(v0),32.92N,32.93N)/0.01N)
.EXTRACT FILE=Power label = pow3284 (1.2*integ(I(v0),32.93N,32.94N)/0.01N)
.EXTRACT FILE=Power label = pow3285 (1.2*integ(I(v0),32.94N,32.95N)/0.01N)
.EXTRACT FILE=Power label = pow3286 (1.2*integ(I(v0),32.95N,32.96N)/0.01N)
.EXTRACT FILE=Power label = pow3287 (1.2*integ(I(v0),32.96N,32.97N)/0.01N)
.EXTRACT FILE=Power label = pow3288 (1.2*integ(I(v0),32.97N,32.98N)/0.01N)
.EXTRACT FILE=Power label = pow3289 (1.2*integ(I(v0),32.98N,32.99N)/0.01N)
.EXTRACT FILE=Power label = pow3290 (1.2*integ(I(v0),32.99N,33.0N)/0.01N)
