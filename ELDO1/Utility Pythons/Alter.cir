.alter Class0_Sample0
.include 'Netlist/Power.cir'
.include 'Class0/Sample_0'

.alter Class1_Sample0
.include 'Netlist/Power.cir'
.include 'Class1/Sample_0'

.alter Class0_Sample1
.include 'Netlist/Power.cir'
.include 'Class0/Sample_1'

.alter Class1_Sample1
.include 'Netlist/Power.cir'
.include 'Class1/Sample_1'

.alter Class0_Sample2
.include 'Netlist/Power.cir'
.include 'Class0/Sample_2'

.alter Class1_Sample2
.include 'Netlist/Power.cir'
.include 'Class1/Sample_2'

.alter Class0_Sample3
.include 'Netlist/Power.cir'
.include 'Class0/Sample_3'

.alter Class1_Sample3
.include 'Netlist/Power.cir'
.include 'Class1/Sample_3'

.alter Class0_Sample4
.include 'Netlist/Power.cir'
.include 'Class0/Sample_4'

.alter Class1_Sample4
.include 'Netlist/Power.cir'
.include 'Class1/Sample_4'

.alter Class0_Sample5
.include 'Netlist/Power.cir'
.include 'Class0/Sample_5'

.alter Class1_Sample5
.include 'Netlist/Power.cir'
.include 'Class1/Sample_5'

.alter Class0_Sample6
.include 'Netlist/Power.cir'
.include 'Class0/Sample_6'

.alter Class1_Sample6
.include 'Netlist/Power.cir'
.include 'Class1/Sample_6'

.alter Class0_Sample7
.include 'Netlist/Power.cir'
.include 'Class0/Sample_7'

.alter Class1_Sample7
.include 'Netlist/Power.cir'
.include 'Class1/Sample_7'

.alter Class0_Sample8
.include 'Netlist/Power.cir'
.include 'Class0/Sample_8'

.alter Class1_Sample8
.include 'Netlist/Power.cir'
.include 'Class1/Sample_8'

.alter Class0_Sample9
.include 'Netlist/Power.cir'
.include 'Class0/Sample_9'

.alter Class1_Sample9
.include 'Netlist/Power.cir'
.include 'Class1/Sample_9'

.alter Class0_Sample10
.include 'Netlist/Power.cir'
.include 'Class0/Sample_10'

.alter Class1_Sample10
.include 'Netlist/Power.cir'
.include 'Class1/Sample_10'

.alter Class0_Sample11
.include 'Netlist/Power.cir'
.include 'Class0/Sample_11'

.alter Class1_Sample11
.include 'Netlist/Power.cir'
.include 'Class1/Sample_11'

.alter Class0_Sample12
.include 'Netlist/Power.cir'
.include 'Class0/Sample_12'

.alter Class1_Sample12
.include 'Netlist/Power.cir'
.include 'Class1/Sample_12'

.alter Class0_Sample13
.include 'Netlist/Power.cir'
.include 'Class0/Sample_13'

.alter Class1_Sample13
.include 'Netlist/Power.cir'
.include 'Class1/Sample_13'

.alter Class0_Sample14
.include 'Netlist/Power.cir'
.include 'Class0/Sample_14'

.alter Class1_Sample14
.include 'Netlist/Power.cir'
.include 'Class1/Sample_14'

.alter Class0_Sample15
.include 'Netlist/Power.cir'
.include 'Class0/Sample_15'

.alter Class1_Sample15
.include 'Netlist/Power.cir'
.include 'Class1/Sample_15'

.alter Class0_Sample16
.include 'Netlist/Power.cir'
.include 'Class0/Sample_16'

.alter Class1_Sample16
.include 'Netlist/Power.cir'
.include 'Class1/Sample_16'

.alter Class0_Sample17
.include 'Netlist/Power.cir'
.include 'Class0/Sample_17'

.alter Class1_Sample17
.include 'Netlist/Power.cir'
.include 'Class1/Sample_17'

.alter Class0_Sample18
.include 'Netlist/Power.cir'
.include 'Class0/Sample_18'

.alter Class1_Sample18
.include 'Netlist/Power.cir'
.include 'Class1/Sample_18'

.alter Class0_Sample19
.include 'Netlist/Power.cir'
.include 'Class0/Sample_19'

.alter Class1_Sample19
.include 'Netlist/Power.cir'
.include 'Class1/Sample_19'

.alter Class0_Sample20
.include 'Netlist/Power.cir'
.include 'Class0/Sample_20'

.alter Class1_Sample20
.include 'Netlist/Power.cir'
.include 'Class1/Sample_20'

.alter Class0_Sample21
.include 'Netlist/Power.cir'
.include 'Class0/Sample_21'

.alter Class1_Sample21
.include 'Netlist/Power.cir'
.include 'Class1/Sample_21'

.alter Class0_Sample22
.include 'Netlist/Power.cir'
.include 'Class0/Sample_22'

.alter Class1_Sample22
.include 'Netlist/Power.cir'
.include 'Class1/Sample_22'

.alter Class0_Sample23
.include 'Netlist/Power.cir'
.include 'Class0/Sample_23'

.alter Class1_Sample23
.include 'Netlist/Power.cir'
.include 'Class1/Sample_23'

.alter Class0_Sample24
.include 'Netlist/Power.cir'
.include 'Class0/Sample_24'

.alter Class1_Sample24
.include 'Netlist/Power.cir'
.include 'Class1/Sample_24'

.alter Class0_Sample25
.include 'Netlist/Power.cir'
.include 'Class0/Sample_25'

.alter Class1_Sample25
.include 'Netlist/Power.cir'
.include 'Class1/Sample_25'

.alter Class0_Sample26
.include 'Netlist/Power.cir'
.include 'Class0/Sample_26'

.alter Class1_Sample26
.include 'Netlist/Power.cir'
.include 'Class1/Sample_26'

.alter Class0_Sample27
.include 'Netlist/Power.cir'
.include 'Class0/Sample_27'

.alter Class1_Sample27
.include 'Netlist/Power.cir'
.include 'Class1/Sample_27'

.alter Class0_Sample28
.include 'Netlist/Power.cir'
.include 'Class0/Sample_28'

.alter Class1_Sample28
.include 'Netlist/Power.cir'
.include 'Class1/Sample_28'

.alter Class0_Sample29
.include 'Netlist/Power.cir'
.include 'Class0/Sample_29'

.alter Class1_Sample29
.include 'Netlist/Power.cir'
.include 'Class1/Sample_29'

.alter Class0_Sample30
.include 'Netlist/Power.cir'
.include 'Class0/Sample_30'

.alter Class1_Sample30
.include 'Netlist/Power.cir'
.include 'Class1/Sample_30'

.alter Class0_Sample31
.include 'Netlist/Power.cir'
.include 'Class0/Sample_31'

.alter Class1_Sample31
.include 'Netlist/Power.cir'
.include 'Class1/Sample_31'

.alter Class0_Sample32
.include 'Netlist/Power.cir'
.include 'Class0/Sample_32'

.alter Class1_Sample32
.include 'Netlist/Power.cir'
.include 'Class1/Sample_32'

.alter Class0_Sample33
.include 'Netlist/Power.cir'
.include 'Class0/Sample_33'

.alter Class1_Sample33
.include 'Netlist/Power.cir'
.include 'Class1/Sample_33'

.alter Class0_Sample34
.include 'Netlist/Power.cir'
.include 'Class0/Sample_34'

.alter Class1_Sample34
.include 'Netlist/Power.cir'
.include 'Class1/Sample_34'

.alter Class0_Sample35
.include 'Netlist/Power.cir'
.include 'Class0/Sample_35'

.alter Class1_Sample35
.include 'Netlist/Power.cir'
.include 'Class1/Sample_35'

.alter Class0_Sample36
.include 'Netlist/Power.cir'
.include 'Class0/Sample_36'

.alter Class1_Sample36
.include 'Netlist/Power.cir'
.include 'Class1/Sample_36'

.alter Class0_Sample37
.include 'Netlist/Power.cir'
.include 'Class0/Sample_37'

.alter Class1_Sample37
.include 'Netlist/Power.cir'
.include 'Class1/Sample_37'

.alter Class0_Sample38
.include 'Netlist/Power.cir'
.include 'Class0/Sample_38'

.alter Class1_Sample38
.include 'Netlist/Power.cir'
.include 'Class1/Sample_38'

.alter Class0_Sample39
.include 'Netlist/Power.cir'
.include 'Class0/Sample_39'

.alter Class1_Sample39
.include 'Netlist/Power.cir'
.include 'Class1/Sample_39'

.alter Class0_Sample40
.include 'Netlist/Power.cir'
.include 'Class0/Sample_40'

.alter Class1_Sample40
.include 'Netlist/Power.cir'
.include 'Class1/Sample_40'

.alter Class0_Sample41
.include 'Netlist/Power.cir'
.include 'Class0/Sample_41'

.alter Class1_Sample41
.include 'Netlist/Power.cir'
.include 'Class1/Sample_41'

.alter Class0_Sample42
.include 'Netlist/Power.cir'
.include 'Class0/Sample_42'

.alter Class1_Sample42
.include 'Netlist/Power.cir'
.include 'Class1/Sample_42'

.alter Class0_Sample43
.include 'Netlist/Power.cir'
.include 'Class0/Sample_43'

.alter Class1_Sample43
.include 'Netlist/Power.cir'
.include 'Class1/Sample_43'

.alter Class0_Sample44
.include 'Netlist/Power.cir'
.include 'Class0/Sample_44'

.alter Class1_Sample44
.include 'Netlist/Power.cir'
.include 'Class1/Sample_44'

.alter Class0_Sample45
.include 'Netlist/Power.cir'
.include 'Class0/Sample_45'

.alter Class1_Sample45
.include 'Netlist/Power.cir'
.include 'Class1/Sample_45'

.alter Class0_Sample46
.include 'Netlist/Power.cir'
.include 'Class0/Sample_46'

.alter Class1_Sample46
.include 'Netlist/Power.cir'
.include 'Class1/Sample_46'

.alter Class0_Sample47
.include 'Netlist/Power.cir'
.include 'Class0/Sample_47'

.alter Class1_Sample47
.include 'Netlist/Power.cir'
.include 'Class1/Sample_47'

.alter Class0_Sample48
.include 'Netlist/Power.cir'
.include 'Class0/Sample_48'

.alter Class1_Sample48
.include 'Netlist/Power.cir'
.include 'Class1/Sample_48'

.alter Class0_Sample49
.include 'Netlist/Power.cir'
.include 'Class0/Sample_49'

.alter Class1_Sample49
.include 'Netlist/Power.cir'
.include 'Class1/Sample_49'

.alter Class0_Sample50
.include 'Netlist/Power.cir'
.include 'Class0/Sample_50'

.alter Class1_Sample50
.include 'Netlist/Power.cir'
.include 'Class1/Sample_50'

.alter Class0_Sample51
.include 'Netlist/Power.cir'
.include 'Class0/Sample_51'

.alter Class1_Sample51
.include 'Netlist/Power.cir'
.include 'Class1/Sample_51'

.alter Class0_Sample52
.include 'Netlist/Power.cir'
.include 'Class0/Sample_52'

.alter Class1_Sample52
.include 'Netlist/Power.cir'
.include 'Class1/Sample_52'

.alter Class0_Sample53
.include 'Netlist/Power.cir'
.include 'Class0/Sample_53'

.alter Class1_Sample53
.include 'Netlist/Power.cir'
.include 'Class1/Sample_53'

.alter Class0_Sample54
.include 'Netlist/Power.cir'
.include 'Class0/Sample_54'

.alter Class1_Sample54
.include 'Netlist/Power.cir'
.include 'Class1/Sample_54'

.alter Class0_Sample55
.include 'Netlist/Power.cir'
.include 'Class0/Sample_55'

.alter Class1_Sample55
.include 'Netlist/Power.cir'
.include 'Class1/Sample_55'

.alter Class0_Sample56
.include 'Netlist/Power.cir'
.include 'Class0/Sample_56'

.alter Class1_Sample56
.include 'Netlist/Power.cir'
.include 'Class1/Sample_56'

.alter Class0_Sample57
.include 'Netlist/Power.cir'
.include 'Class0/Sample_57'

.alter Class1_Sample57
.include 'Netlist/Power.cir'
.include 'Class1/Sample_57'

.alter Class0_Sample58
.include 'Netlist/Power.cir'
.include 'Class0/Sample_58'

.alter Class1_Sample58
.include 'Netlist/Power.cir'
.include 'Class1/Sample_58'

.alter Class0_Sample59
.include 'Netlist/Power.cir'
.include 'Class0/Sample_59'

.alter Class1_Sample59
.include 'Netlist/Power.cir'
.include 'Class1/Sample_59'

.alter Class0_Sample60
.include 'Netlist/Power.cir'
.include 'Class0/Sample_60'

.alter Class1_Sample60
.include 'Netlist/Power.cir'
.include 'Class1/Sample_60'

.alter Class0_Sample61
.include 'Netlist/Power.cir'
.include 'Class0/Sample_61'

.alter Class1_Sample61
.include 'Netlist/Power.cir'
.include 'Class1/Sample_61'

.alter Class0_Sample62
.include 'Netlist/Power.cir'
.include 'Class0/Sample_62'

.alter Class1_Sample62
.include 'Netlist/Power.cir'
.include 'Class1/Sample_62'

.alter Class0_Sample63
.include 'Netlist/Power.cir'
.include 'Class0/Sample_63'

.alter Class1_Sample63
.include 'Netlist/Power.cir'
.include 'Class1/Sample_63'

.alter Class0_Sample64
.include 'Netlist/Power.cir'
.include 'Class0/Sample_64'

.alter Class1_Sample64
.include 'Netlist/Power.cir'
.include 'Class1/Sample_64'

.alter Class0_Sample65
.include 'Netlist/Power.cir'
.include 'Class0/Sample_65'

.alter Class1_Sample65
.include 'Netlist/Power.cir'
.include 'Class1/Sample_65'

.alter Class0_Sample66
.include 'Netlist/Power.cir'
.include 'Class0/Sample_66'

.alter Class1_Sample66
.include 'Netlist/Power.cir'
.include 'Class1/Sample_66'

.alter Class0_Sample67
.include 'Netlist/Power.cir'
.include 'Class0/Sample_67'

.alter Class1_Sample67
.include 'Netlist/Power.cir'
.include 'Class1/Sample_67'

.alter Class0_Sample68
.include 'Netlist/Power.cir'
.include 'Class0/Sample_68'

.alter Class1_Sample68
.include 'Netlist/Power.cir'
.include 'Class1/Sample_68'

.alter Class0_Sample69
.include 'Netlist/Power.cir'
.include 'Class0/Sample_69'

.alter Class1_Sample69
.include 'Netlist/Power.cir'
.include 'Class1/Sample_69'

.alter Class0_Sample70
.include 'Netlist/Power.cir'
.include 'Class0/Sample_70'

.alter Class1_Sample70
.include 'Netlist/Power.cir'
.include 'Class1/Sample_70'

.alter Class0_Sample71
.include 'Netlist/Power.cir'
.include 'Class0/Sample_71'

.alter Class1_Sample71
.include 'Netlist/Power.cir'
.include 'Class1/Sample_71'

.alter Class0_Sample72
.include 'Netlist/Power.cir'
.include 'Class0/Sample_72'

.alter Class1_Sample72
.include 'Netlist/Power.cir'
.include 'Class1/Sample_72'

.alter Class0_Sample73
.include 'Netlist/Power.cir'
.include 'Class0/Sample_73'

.alter Class1_Sample73
.include 'Netlist/Power.cir'
.include 'Class1/Sample_73'

.alter Class0_Sample74
.include 'Netlist/Power.cir'
.include 'Class0/Sample_74'

.alter Class1_Sample74
.include 'Netlist/Power.cir'
.include 'Class1/Sample_74'

.alter Class0_Sample75
.include 'Netlist/Power.cir'
.include 'Class0/Sample_75'

.alter Class1_Sample75
.include 'Netlist/Power.cir'
.include 'Class1/Sample_75'

.alter Class0_Sample76
.include 'Netlist/Power.cir'
.include 'Class0/Sample_76'

.alter Class1_Sample76
.include 'Netlist/Power.cir'
.include 'Class1/Sample_76'

.alter Class0_Sample77
.include 'Netlist/Power.cir'
.include 'Class0/Sample_77'

.alter Class1_Sample77
.include 'Netlist/Power.cir'
.include 'Class1/Sample_77'

.alter Class0_Sample78
.include 'Netlist/Power.cir'
.include 'Class0/Sample_78'

.alter Class1_Sample78
.include 'Netlist/Power.cir'
.include 'Class1/Sample_78'

.alter Class0_Sample79
.include 'Netlist/Power.cir'
.include 'Class0/Sample_79'

.alter Class1_Sample79
.include 'Netlist/Power.cir'
.include 'Class1/Sample_79'

.alter Class0_Sample80
.include 'Netlist/Power.cir'
.include 'Class0/Sample_80'

.alter Class1_Sample80
.include 'Netlist/Power.cir'
.include 'Class1/Sample_80'

.alter Class0_Sample81
.include 'Netlist/Power.cir'
.include 'Class0/Sample_81'

.alter Class1_Sample81
.include 'Netlist/Power.cir'
.include 'Class1/Sample_81'

.alter Class0_Sample82
.include 'Netlist/Power.cir'
.include 'Class0/Sample_82'

.alter Class1_Sample82
.include 'Netlist/Power.cir'
.include 'Class1/Sample_82'

.alter Class0_Sample83
.include 'Netlist/Power.cir'
.include 'Class0/Sample_83'

.alter Class1_Sample83
.include 'Netlist/Power.cir'
.include 'Class1/Sample_83'

.alter Class0_Sample84
.include 'Netlist/Power.cir'
.include 'Class0/Sample_84'

.alter Class1_Sample84
.include 'Netlist/Power.cir'
.include 'Class1/Sample_84'

.alter Class0_Sample85
.include 'Netlist/Power.cir'
.include 'Class0/Sample_85'

.alter Class1_Sample85
.include 'Netlist/Power.cir'
.include 'Class1/Sample_85'

.alter Class0_Sample86
.include 'Netlist/Power.cir'
.include 'Class0/Sample_86'

.alter Class1_Sample86
.include 'Netlist/Power.cir'
.include 'Class1/Sample_86'

.alter Class0_Sample87
.include 'Netlist/Power.cir'
.include 'Class0/Sample_87'

.alter Class1_Sample87
.include 'Netlist/Power.cir'
.include 'Class1/Sample_87'

.alter Class0_Sample88
.include 'Netlist/Power.cir'
.include 'Class0/Sample_88'

.alter Class1_Sample88
.include 'Netlist/Power.cir'
.include 'Class1/Sample_88'

.alter Class0_Sample89
.include 'Netlist/Power.cir'
.include 'Class0/Sample_89'

.alter Class1_Sample89
.include 'Netlist/Power.cir'
.include 'Class1/Sample_89'

.alter Class0_Sample90
.include 'Netlist/Power.cir'
.include 'Class0/Sample_90'

.alter Class1_Sample90
.include 'Netlist/Power.cir'
.include 'Class1/Sample_90'

.alter Class0_Sample91
.include 'Netlist/Power.cir'
.include 'Class0/Sample_91'

.alter Class1_Sample91
.include 'Netlist/Power.cir'
.include 'Class1/Sample_91'

.alter Class0_Sample92
.include 'Netlist/Power.cir'
.include 'Class0/Sample_92'

.alter Class1_Sample92
.include 'Netlist/Power.cir'
.include 'Class1/Sample_92'

.alter Class0_Sample93
.include 'Netlist/Power.cir'
.include 'Class0/Sample_93'

.alter Class1_Sample93
.include 'Netlist/Power.cir'
.include 'Class1/Sample_93'

.alter Class0_Sample94
.include 'Netlist/Power.cir'
.include 'Class0/Sample_94'

.alter Class1_Sample94
.include 'Netlist/Power.cir'
.include 'Class1/Sample_94'

.alter Class0_Sample95
.include 'Netlist/Power.cir'
.include 'Class0/Sample_95'

.alter Class1_Sample95
.include 'Netlist/Power.cir'
.include 'Class1/Sample_95'

.alter Class0_Sample96
.include 'Netlist/Power.cir'
.include 'Class0/Sample_96'

.alter Class1_Sample96
.include 'Netlist/Power.cir'
.include 'Class1/Sample_96'

.alter Class0_Sample97
.include 'Netlist/Power.cir'
.include 'Class0/Sample_97'

.alter Class1_Sample97
.include 'Netlist/Power.cir'
.include 'Class1/Sample_97'

.alter Class0_Sample98
.include 'Netlist/Power.cir'
.include 'Class0/Sample_98'

.alter Class1_Sample98
.include 'Netlist/Power.cir'
.include 'Class1/Sample_98'

.alter Class0_Sample99
.include 'Netlist/Power.cir'
.include 'Class0/Sample_99'

.alter Class1_Sample99
.include 'Netlist/Power.cir'
.include 'Class1/Sample_99'

.alter Class0_Sample100
.include 'Netlist/Power.cir'
.include 'Class0/Sample_100'

.alter Class1_Sample100
.include 'Netlist/Power.cir'
.include 'Class1/Sample_100'

.alter Class0_Sample101
.include 'Netlist/Power.cir'
.include 'Class0/Sample_101'

.alter Class1_Sample101
.include 'Netlist/Power.cir'
.include 'Class1/Sample_101'

.alter Class0_Sample102
.include 'Netlist/Power.cir'
.include 'Class0/Sample_102'

.alter Class1_Sample102
.include 'Netlist/Power.cir'
.include 'Class1/Sample_102'

.alter Class0_Sample103
.include 'Netlist/Power.cir'
.include 'Class0/Sample_103'

.alter Class1_Sample103
.include 'Netlist/Power.cir'
.include 'Class1/Sample_103'

.alter Class0_Sample104
.include 'Netlist/Power.cir'
.include 'Class0/Sample_104'

.alter Class1_Sample104
.include 'Netlist/Power.cir'
.include 'Class1/Sample_104'

.alter Class0_Sample105
.include 'Netlist/Power.cir'
.include 'Class0/Sample_105'

.alter Class1_Sample105
.include 'Netlist/Power.cir'
.include 'Class1/Sample_105'

.alter Class0_Sample106
.include 'Netlist/Power.cir'
.include 'Class0/Sample_106'

.alter Class1_Sample106
.include 'Netlist/Power.cir'
.include 'Class1/Sample_106'

.alter Class0_Sample107
.include 'Netlist/Power.cir'
.include 'Class0/Sample_107'

.alter Class1_Sample107
.include 'Netlist/Power.cir'
.include 'Class1/Sample_107'

.alter Class0_Sample108
.include 'Netlist/Power.cir'
.include 'Class0/Sample_108'

.alter Class1_Sample108
.include 'Netlist/Power.cir'
.include 'Class1/Sample_108'

.alter Class0_Sample109
.include 'Netlist/Power.cir'
.include 'Class0/Sample_109'

.alter Class1_Sample109
.include 'Netlist/Power.cir'
.include 'Class1/Sample_109'

.alter Class0_Sample110
.include 'Netlist/Power.cir'
.include 'Class0/Sample_110'

.alter Class1_Sample110
.include 'Netlist/Power.cir'
.include 'Class1/Sample_110'

.alter Class0_Sample111
.include 'Netlist/Power.cir'
.include 'Class0/Sample_111'

.alter Class1_Sample111
.include 'Netlist/Power.cir'
.include 'Class1/Sample_111'

.alter Class0_Sample112
.include 'Netlist/Power.cir'
.include 'Class0/Sample_112'

.alter Class1_Sample112
.include 'Netlist/Power.cir'
.include 'Class1/Sample_112'

.alter Class0_Sample113
.include 'Netlist/Power.cir'
.include 'Class0/Sample_113'

.alter Class1_Sample113
.include 'Netlist/Power.cir'
.include 'Class1/Sample_113'

.alter Class0_Sample114
.include 'Netlist/Power.cir'
.include 'Class0/Sample_114'

.alter Class1_Sample114
.include 'Netlist/Power.cir'
.include 'Class1/Sample_114'

.alter Class0_Sample115
.include 'Netlist/Power.cir'
.include 'Class0/Sample_115'

.alter Class1_Sample115
.include 'Netlist/Power.cir'
.include 'Class1/Sample_115'

.alter Class0_Sample116
.include 'Netlist/Power.cir'
.include 'Class0/Sample_116'

.alter Class1_Sample116
.include 'Netlist/Power.cir'
.include 'Class1/Sample_116'

.alter Class0_Sample117
.include 'Netlist/Power.cir'
.include 'Class0/Sample_117'

.alter Class1_Sample117
.include 'Netlist/Power.cir'
.include 'Class1/Sample_117'

.alter Class0_Sample118
.include 'Netlist/Power.cir'
.include 'Class0/Sample_118'

.alter Class1_Sample118
.include 'Netlist/Power.cir'
.include 'Class1/Sample_118'

.alter Class0_Sample119
.include 'Netlist/Power.cir'
.include 'Class0/Sample_119'

.alter Class1_Sample119
.include 'Netlist/Power.cir'
.include 'Class1/Sample_119'
