.EXTRACT FILE=Power label = pow0 (SUPPLY*integ(I(v0),0N,0.2N)/0.2N)
.EXTRACT FILE=Power label = pow1 (SUPPLY*integ(I(v0),0.2N,0.4N)/0.2N)
.EXTRACT FILE=Power label = pow2 (SUPPLY*integ(I(v0),0.4N,0.6000000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow3 (SUPPLY*integ(I(v0),0.6000000000000001N,0.8N)/0.2N)
.EXTRACT FILE=Power label = pow4 (SUPPLY*integ(I(v0),0.8N,1.0N)/0.2N)
.EXTRACT FILE=Power label = pow5 (SUPPLY*integ(I(v0),1.0N,1.2N)/0.2N)
.EXTRACT FILE=Power label = pow6 (SUPPLY*integ(I(v0),1.2N,1.4N)/0.2N)
.EXTRACT FILE=Power label = pow7 (SUPPLY*integ(I(v0),1.4N,1.5999999999999999N)/0.2N)
.EXTRACT FILE=Power label = pow8 (SUPPLY*integ(I(v0),1.5999999999999999N,1.7999999999999998N)/0.2N)
.EXTRACT FILE=Power label = pow9 (SUPPLY*integ(I(v0),1.7999999999999998N,1.9999999999999998N)/0.2N)
.EXTRACT FILE=Power label = pow10 (SUPPLY*integ(I(v0),1.9999999999999998N,2.1999999999999997N)/0.2N)
.EXTRACT FILE=Power label = pow11 (SUPPLY*integ(I(v0),2.1999999999999997N,2.4N)/0.2N)
.EXTRACT FILE=Power label = pow12 (SUPPLY*integ(I(v0),2.4N,2.6N)/0.2N)
.EXTRACT FILE=Power label = pow13 (SUPPLY*integ(I(v0),2.6N,2.8000000000000003N)/0.2N)
.EXTRACT FILE=Power label = pow14 (SUPPLY*integ(I(v0),2.8000000000000003N,3.0000000000000004N)/0.2N)
.EXTRACT FILE=Power label = pow15 (SUPPLY*integ(I(v0),3.0000000000000004N,3.2000000000000006N)/0.2N)
.EXTRACT FILE=Power label = pow16 (SUPPLY*integ(I(v0),3.2000000000000006N,3.400000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow17 (SUPPLY*integ(I(v0),3.400000000000001N,3.600000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow18 (SUPPLY*integ(I(v0),3.600000000000001N,3.800000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow19 (SUPPLY*integ(I(v0),3.800000000000001N,4.000000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow20 (SUPPLY*integ(I(v0),4.000000000000001N,4.200000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow21 (SUPPLY*integ(I(v0),4.200000000000001N,4.400000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow22 (SUPPLY*integ(I(v0),4.400000000000001N,4.600000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow23 (SUPPLY*integ(I(v0),4.600000000000001N,4.800000000000002N)/0.2N)
.EXTRACT FILE=Power label = pow24 (SUPPLY*integ(I(v0),4.800000000000002N,5.000000000000002N)/0.2N)
.EXTRACT FILE=Power label = pow25 (SUPPLY*integ(I(v0),5.000000000000002N,5.200000000000002N)/0.2N)
.EXTRACT FILE=Power label = pow26 (SUPPLY*integ(I(v0),5.200000000000002N,5.400000000000002N)/0.2N)
.EXTRACT FILE=Power label = pow27 (SUPPLY*integ(I(v0),5.400000000000002N,5.600000000000002N)/0.2N)
.EXTRACT FILE=Power label = pow28 (SUPPLY*integ(I(v0),5.600000000000002N,5.8000000000000025N)/0.2N)
.EXTRACT FILE=Power label = pow29 (SUPPLY*integ(I(v0),5.8000000000000025N,6.000000000000003N)/0.2N)
.EXTRACT FILE=Power label = pow30 (SUPPLY*integ(I(v0),6.000000000000003N,6.200000000000003N)/0.2N)
.EXTRACT FILE=Power label = pow31 (SUPPLY*integ(I(v0),6.200000000000003N,6.400000000000003N)/0.2N)
.EXTRACT FILE=Power label = pow32 (SUPPLY*integ(I(v0),6.400000000000003N,6.600000000000003N)/0.2N)
.EXTRACT FILE=Power label = pow33 (SUPPLY*integ(I(v0),6.600000000000003N,6.800000000000003N)/0.2N)
.EXTRACT FILE=Power label = pow34 (SUPPLY*integ(I(v0),6.800000000000003N,7.0000000000000036N)/0.2N)
.EXTRACT FILE=Power label = pow35 (SUPPLY*integ(I(v0),7.0000000000000036N,7.200000000000004N)/0.2N)
.EXTRACT FILE=Power label = pow36 (SUPPLY*integ(I(v0),7.200000000000004N,7.400000000000004N)/0.2N)
.EXTRACT FILE=Power label = pow37 (SUPPLY*integ(I(v0),7.400000000000004N,7.600000000000004N)/0.2N)
.EXTRACT FILE=Power label = pow38 (SUPPLY*integ(I(v0),7.600000000000004N,7.800000000000004N)/0.2N)
.EXTRACT FILE=Power label = pow39 (SUPPLY*integ(I(v0),7.800000000000004N,8.000000000000004N)/0.2N)
.EXTRACT FILE=Power label = pow40 (SUPPLY*integ(I(v0),8.000000000000004N,8.200000000000003N)/0.2N)
.EXTRACT FILE=Power label = pow41 (SUPPLY*integ(I(v0),8.200000000000003N,8.400000000000002N)/0.2N)
.EXTRACT FILE=Power label = pow42 (SUPPLY*integ(I(v0),8.400000000000002N,8.600000000000001N)/0.2N)
.EXTRACT FILE=Power label = pow43 (SUPPLY*integ(I(v0),8.600000000000001N,8.8N)/0.2N)
.EXTRACT FILE=Power label = pow44 (SUPPLY*integ(I(v0),8.8N,9.0N)/0.2N)
.EXTRACT FILE=Power label = pow45 (SUPPLY*integ(I(v0),9.0N,9.2N)/0.2N)
.EXTRACT FILE=Power label = pow46 (SUPPLY*integ(I(v0),9.2N,9.399999999999999N)/0.2N)
.EXTRACT FILE=Power label = pow47 (SUPPLY*integ(I(v0),9.399999999999999N,9.599999999999998N)/0.2N)
.EXTRACT FILE=Power label = pow48 (SUPPLY*integ(I(v0),9.599999999999998N,9.799999999999997N)/0.2N)
.EXTRACT FILE=Power label = pow49 (SUPPLY*integ(I(v0),9.799999999999997N,9.999999999999996N)/0.2N)
.EXTRACT FILE=Power label = pow50 (SUPPLY*integ(I(v0),9.999999999999996N,10.199999999999996N)/0.2N)
.EXTRACT FILE=Power label = pow51 (SUPPLY*integ(I(v0),10.199999999999996N,10.399999999999995N)/0.2N)
.EXTRACT FILE=Power label = pow52 (SUPPLY*integ(I(v0),10.399999999999995N,10.599999999999994N)/0.2N)
.EXTRACT FILE=Power label = pow53 (SUPPLY*integ(I(v0),10.599999999999994N,10.799999999999994N)/0.2N)
.EXTRACT FILE=Power label = pow54 (SUPPLY*integ(I(v0),10.799999999999994N,10.999999999999993N)/0.2N)
.EXTRACT FILE=Power label = pow55 (SUPPLY*integ(I(v0),10.999999999999993N,11.199999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow56 (SUPPLY*integ(I(v0),11.199999999999992N,11.399999999999991N)/0.2N)
.EXTRACT FILE=Power label = pow57 (SUPPLY*integ(I(v0),11.399999999999991N,11.59999999999999N)/0.2N)
.EXTRACT FILE=Power label = pow58 (SUPPLY*integ(I(v0),11.59999999999999N,11.79999999999999N)/0.2N)
.EXTRACT FILE=Power label = pow59 (SUPPLY*integ(I(v0),11.79999999999999N,11.99999999999999N)/0.2N)
.EXTRACT FILE=Power label = pow60 (SUPPLY*integ(I(v0),11.99999999999999N,12.199999999999989N)/0.2N)
.EXTRACT FILE=Power label = pow61 (SUPPLY*integ(I(v0),12.199999999999989N,12.399999999999988N)/0.2N)
.EXTRACT FILE=Power label = pow62 (SUPPLY*integ(I(v0),12.399999999999988N,12.599999999999987N)/0.2N)
.EXTRACT FILE=Power label = pow63 (SUPPLY*integ(I(v0),12.599999999999987N,12.799999999999986N)/0.2N)
.EXTRACT FILE=Power label = pow64 (SUPPLY*integ(I(v0),12.799999999999986N,12.999999999999986N)/0.2N)
.EXTRACT FILE=Power label = pow65 (SUPPLY*integ(I(v0),12.999999999999986N,13.199999999999985N)/0.2N)
.EXTRACT FILE=Power label = pow66 (SUPPLY*integ(I(v0),13.199999999999985N,13.399999999999984N)/0.2N)
.EXTRACT FILE=Power label = pow67 (SUPPLY*integ(I(v0),13.399999999999984N,13.599999999999984N)/0.2N)
.EXTRACT FILE=Power label = pow68 (SUPPLY*integ(I(v0),13.599999999999984N,13.799999999999983N)/0.2N)
.EXTRACT FILE=Power label = pow69 (SUPPLY*integ(I(v0),13.799999999999983N,13.999999999999982N)/0.2N)
.EXTRACT FILE=Power label = pow70 (SUPPLY*integ(I(v0),13.999999999999982N,14.199999999999982N)/0.2N)
.EXTRACT FILE=Power label = pow71 (SUPPLY*integ(I(v0),14.199999999999982N,14.39999999999998N)/0.2N)
.EXTRACT FILE=Power label = pow72 (SUPPLY*integ(I(v0),14.39999999999998N,14.59999999999998N)/0.2N)
.EXTRACT FILE=Power label = pow73 (SUPPLY*integ(I(v0),14.59999999999998N,14.79999999999998N)/0.2N)
.EXTRACT FILE=Power label = pow74 (SUPPLY*integ(I(v0),14.79999999999998N,14.999999999999979N)/0.2N)
.EXTRACT FILE=Power label = pow75 (SUPPLY*integ(I(v0),14.999999999999979N,15.199999999999978N)/0.2N)
.EXTRACT FILE=Power label = pow76 (SUPPLY*integ(I(v0),15.199999999999978N,15.399999999999977N)/0.2N)
.EXTRACT FILE=Power label = pow77 (SUPPLY*integ(I(v0),15.399999999999977N,15.599999999999977N)/0.2N)
.EXTRACT FILE=Power label = pow78 (SUPPLY*integ(I(v0),15.599999999999977N,15.799999999999976N)/0.2N)
.EXTRACT FILE=Power label = pow79 (SUPPLY*integ(I(v0),15.799999999999976N,15.999999999999975N)/0.2N)
.EXTRACT FILE=Power label = pow80 (SUPPLY*integ(I(v0),15.999999999999975N,16.199999999999974N)/0.2N)
.EXTRACT FILE=Power label = pow81 (SUPPLY*integ(I(v0),16.199999999999974N,16.399999999999974N)/0.2N)
.EXTRACT FILE=Power label = pow82 (SUPPLY*integ(I(v0),16.399999999999974N,16.599999999999973N)/0.2N)
.EXTRACT FILE=Power label = pow83 (SUPPLY*integ(I(v0),16.599999999999973N,16.799999999999972N)/0.2N)
.EXTRACT FILE=Power label = pow84 (SUPPLY*integ(I(v0),16.799999999999972N,16.99999999999997N)/0.2N)
.EXTRACT FILE=Power label = pow85 (SUPPLY*integ(I(v0),16.99999999999997N,17.19999999999997N)/0.2N)
.EXTRACT FILE=Power label = pow86 (SUPPLY*integ(I(v0),17.19999999999997N,17.39999999999997N)/0.2N)
.EXTRACT FILE=Power label = pow87 (SUPPLY*integ(I(v0),17.39999999999997N,17.59999999999997N)/0.2N)
.EXTRACT FILE=Power label = pow88 (SUPPLY*integ(I(v0),17.59999999999997N,17.79999999999997N)/0.2N)
.EXTRACT FILE=Power label = pow89 (SUPPLY*integ(I(v0),17.79999999999997N,17.999999999999968N)/0.2N)
.EXTRACT FILE=Power label = pow90 (SUPPLY*integ(I(v0),17.999999999999968N,18.199999999999967N)/0.2N)
.EXTRACT FILE=Power label = pow91 (SUPPLY*integ(I(v0),18.199999999999967N,18.399999999999967N)/0.2N)
.EXTRACT FILE=Power label = pow92 (SUPPLY*integ(I(v0),18.399999999999967N,18.599999999999966N)/0.2N)
.EXTRACT FILE=Power label = pow93 (SUPPLY*integ(I(v0),18.599999999999966N,18.799999999999965N)/0.2N)
.EXTRACT FILE=Power label = pow94 (SUPPLY*integ(I(v0),18.799999999999965N,18.999999999999964N)/0.2N)
.EXTRACT FILE=Power label = pow95 (SUPPLY*integ(I(v0),18.999999999999964N,19.199999999999964N)/0.2N)
.EXTRACT FILE=Power label = pow96 (SUPPLY*integ(I(v0),19.199999999999964N,19.399999999999963N)/0.2N)
.EXTRACT FILE=Power label = pow97 (SUPPLY*integ(I(v0),19.399999999999963N,19.599999999999962N)/0.2N)
.EXTRACT FILE=Power label = pow98 (SUPPLY*integ(I(v0),19.599999999999962N,19.79999999999996N)/0.2N)
.EXTRACT FILE=Power label = pow99 (SUPPLY*integ(I(v0),19.79999999999996N,19.99999999999996N)/0.2N)
.EXTRACT FILE=Power label = pow100 (SUPPLY*integ(I(v0),19.99999999999996N,20.19999999999996N)/0.2N)
.EXTRACT FILE=Power label = pow101 (SUPPLY*integ(I(v0),20.19999999999996N,20.39999999999996N)/0.2N)
.EXTRACT FILE=Power label = pow102 (SUPPLY*integ(I(v0),20.39999999999996N,20.59999999999996N)/0.2N)
.EXTRACT FILE=Power label = pow103 (SUPPLY*integ(I(v0),20.59999999999996N,20.799999999999958N)/0.2N)
.EXTRACT FILE=Power label = pow104 (SUPPLY*integ(I(v0),20.799999999999958N,20.999999999999957N)/0.2N)
.EXTRACT FILE=Power label = pow105 (SUPPLY*integ(I(v0),20.999999999999957N,21.199999999999957N)/0.2N)
.EXTRACT FILE=Power label = pow106 (SUPPLY*integ(I(v0),21.199999999999957N,21.399999999999956N)/0.2N)
.EXTRACT FILE=Power label = pow107 (SUPPLY*integ(I(v0),21.399999999999956N,21.599999999999955N)/0.2N)
.EXTRACT FILE=Power label = pow108 (SUPPLY*integ(I(v0),21.599999999999955N,21.799999999999955N)/0.2N)
.EXTRACT FILE=Power label = pow109 (SUPPLY*integ(I(v0),21.799999999999955N,21.999999999999954N)/0.2N)
.EXTRACT FILE=Power label = pow110 (SUPPLY*integ(I(v0),21.999999999999954N,22.199999999999953N)/0.2N)
.EXTRACT FILE=Power label = pow111 (SUPPLY*integ(I(v0),22.199999999999953N,22.399999999999952N)/0.2N)
.EXTRACT FILE=Power label = pow112 (SUPPLY*integ(I(v0),22.399999999999952N,22.59999999999995N)/0.2N)
.EXTRACT FILE=Power label = pow113 (SUPPLY*integ(I(v0),22.59999999999995N,22.79999999999995N)/0.2N)
.EXTRACT FILE=Power label = pow114 (SUPPLY*integ(I(v0),22.79999999999995N,22.99999999999995N)/0.2N)
.EXTRACT FILE=Power label = pow115 (SUPPLY*integ(I(v0),22.99999999999995N,23.19999999999995N)/0.2N)
.EXTRACT FILE=Power label = pow116 (SUPPLY*integ(I(v0),23.19999999999995N,23.39999999999995N)/0.2N)
.EXTRACT FILE=Power label = pow117 (SUPPLY*integ(I(v0),23.39999999999995N,23.599999999999948N)/0.2N)
.EXTRACT FILE=Power label = pow118 (SUPPLY*integ(I(v0),23.599999999999948N,23.799999999999947N)/0.2N)
.EXTRACT FILE=Power label = pow119 (SUPPLY*integ(I(v0),23.799999999999947N,23.999999999999947N)/0.2N)
.EXTRACT FILE=Power label = pow120 (SUPPLY*integ(I(v0),23.999999999999947N,24.199999999999946N)/0.2N)
.EXTRACT FILE=Power label = pow121 (SUPPLY*integ(I(v0),24.199999999999946N,24.399999999999945N)/0.2N)
.EXTRACT FILE=Power label = pow122 (SUPPLY*integ(I(v0),24.399999999999945N,24.599999999999945N)/0.2N)
.EXTRACT FILE=Power label = pow123 (SUPPLY*integ(I(v0),24.599999999999945N,24.799999999999944N)/0.2N)
.EXTRACT FILE=Power label = pow124 (SUPPLY*integ(I(v0),24.799999999999944N,24.999999999999943N)/0.2N)
.EXTRACT FILE=Power label = pow125 (SUPPLY*integ(I(v0),24.999999999999943N,25.199999999999942N)/0.2N)
.EXTRACT FILE=Power label = pow126 (SUPPLY*integ(I(v0),25.199999999999942N,25.39999999999994N)/0.2N)
.EXTRACT FILE=Power label = pow127 (SUPPLY*integ(I(v0),25.39999999999994N,25.59999999999994N)/0.2N)
.EXTRACT FILE=Power label = pow128 (SUPPLY*integ(I(v0),25.59999999999994N,25.79999999999994N)/0.2N)
.EXTRACT FILE=Power label = pow129 (SUPPLY*integ(I(v0),25.79999999999994N,25.99999999999994N)/0.2N)
.EXTRACT FILE=Power label = pow130 (SUPPLY*integ(I(v0),25.99999999999994N,26.19999999999994N)/0.2N)
.EXTRACT FILE=Power label = pow131 (SUPPLY*integ(I(v0),26.19999999999994N,26.399999999999938N)/0.2N)
.EXTRACT FILE=Power label = pow132 (SUPPLY*integ(I(v0),26.399999999999938N,26.599999999999937N)/0.2N)
.EXTRACT FILE=Power label = pow133 (SUPPLY*integ(I(v0),26.599999999999937N,26.799999999999937N)/0.2N)
.EXTRACT FILE=Power label = pow134 (SUPPLY*integ(I(v0),26.799999999999937N,26.999999999999936N)/0.2N)
.EXTRACT FILE=Power label = pow135 (SUPPLY*integ(I(v0),26.999999999999936N,27.199999999999935N)/0.2N)
.EXTRACT FILE=Power label = pow136 (SUPPLY*integ(I(v0),27.199999999999935N,27.399999999999935N)/0.2N)
.EXTRACT FILE=Power label = pow137 (SUPPLY*integ(I(v0),27.399999999999935N,27.599999999999934N)/0.2N)
.EXTRACT FILE=Power label = pow138 (SUPPLY*integ(I(v0),27.599999999999934N,27.799999999999933N)/0.2N)
.EXTRACT FILE=Power label = pow139 (SUPPLY*integ(I(v0),27.799999999999933N,27.999999999999932N)/0.2N)
.EXTRACT FILE=Power label = pow140 (SUPPLY*integ(I(v0),27.999999999999932N,28.199999999999932N)/0.2N)
.EXTRACT FILE=Power label = pow141 (SUPPLY*integ(I(v0),28.199999999999932N,28.39999999999993N)/0.2N)
.EXTRACT FILE=Power label = pow142 (SUPPLY*integ(I(v0),28.39999999999993N,28.59999999999993N)/0.2N)
.EXTRACT FILE=Power label = pow143 (SUPPLY*integ(I(v0),28.59999999999993N,28.79999999999993N)/0.2N)
.EXTRACT FILE=Power label = pow144 (SUPPLY*integ(I(v0),28.79999999999993N,28.99999999999993N)/0.2N)
.EXTRACT FILE=Power label = pow145 (SUPPLY*integ(I(v0),28.99999999999993N,29.19999999999993N)/0.2N)
.EXTRACT FILE=Power label = pow146 (SUPPLY*integ(I(v0),29.19999999999993N,29.399999999999928N)/0.2N)
.EXTRACT FILE=Power label = pow147 (SUPPLY*integ(I(v0),29.399999999999928N,29.599999999999927N)/0.2N)
.EXTRACT FILE=Power label = pow148 (SUPPLY*integ(I(v0),29.599999999999927N,29.799999999999926N)/0.2N)
.EXTRACT FILE=Power label = pow149 (SUPPLY*integ(I(v0),29.799999999999926N,29.999999999999925N)/0.2N)
.EXTRACT FILE=Power label = pow150 (SUPPLY*integ(I(v0),29.999999999999925N,30.199999999999925N)/0.2N)
.EXTRACT FILE=Power label = pow151 (SUPPLY*integ(I(v0),30.199999999999925N,30.399999999999924N)/0.2N)
.EXTRACT FILE=Power label = pow152 (SUPPLY*integ(I(v0),30.399999999999924N,30.599999999999923N)/0.2N)
.EXTRACT FILE=Power label = pow153 (SUPPLY*integ(I(v0),30.599999999999923N,30.799999999999923N)/0.2N)
.EXTRACT FILE=Power label = pow154 (SUPPLY*integ(I(v0),30.799999999999923N,30.999999999999922N)/0.2N)
.EXTRACT FILE=Power label = pow155 (SUPPLY*integ(I(v0),30.999999999999922N,31.19999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow156 (SUPPLY*integ(I(v0),31.19999999999992N,31.39999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow157 (SUPPLY*integ(I(v0),31.39999999999992N,31.59999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow158 (SUPPLY*integ(I(v0),31.59999999999992N,31.79999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow159 (SUPPLY*integ(I(v0),31.79999999999992N,31.99999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow160 (SUPPLY*integ(I(v0),31.99999999999992N,32.19999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow161 (SUPPLY*integ(I(v0),32.19999999999992N,32.39999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow162 (SUPPLY*integ(I(v0),32.39999999999992N,32.59999999999992N)/0.2N)
.EXTRACT FILE=Power label = pow163 (SUPPLY*integ(I(v0),32.59999999999992N,32.799999999999926N)/0.2N)
.EXTRACT FILE=Power label = pow164 (SUPPLY*integ(I(v0),32.799999999999926N,32.99999999999993N)/0.2N)
